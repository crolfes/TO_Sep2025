* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT SARADC AVDD CLK GO RESULT[0] RESULT[1] RESULT[2] RESULT[3]
+ RESULT[4] RST SAMPLE VALID VDD VIN VIP VREFH VREFL VSS
Xanalog/buflogic.conv.cmpbegin.ccmpbuf1.impl analog/buflogic.conv.cmpbegin.CCMPNR
+ AVDD VSS analog/buflogic.conv.cmpbegin.CCMPNR1 sg13g2f_BUFFD8
Xanalog/buflogic.conv.cmpbegin.ccmpbuf2.impl analog/buflogic.conv.cmpbegin.CCMPNR1
+ AVDD VSS analog/buflogic.CMP sg13g2f_BUFFD16
Xanalog/buflogic.conv.cmpbegin.ccmpnor.impl SAMPLE CLKBUF
+ VALID AVDD VSS analog/buflogic.conv.cmpbegin.CCMPNR sg13g2f_NR3D4
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.ibuf16.impl RESULTN\[1\]
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.ZL sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.ln1.impl analog/buflogic.conv.re2cr\[1\].ren2crh.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.ZNL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.ln2.impl analog/buflogic.conv.re2cr\[1\].ren2crh.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.ZL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zbuf.impl analog/buflogic.conv.re2cr\[1\].ren2crh.ZLD3
+ AVDD VSS analog/CRH\[0\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zdel_1.impl1 analog/buflogic.conv.re2cr\[1\].ren2crh.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.zdel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zdel_1.impl2 analog/buflogic.conv.re2cr\[1\].ren2crh.zdel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.ZLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zdel_2.impl1 analog/buflogic.conv.re2cr\[1\].ren2crh.ZLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.zdel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zdel_2.impl2 analog/buflogic.conv.re2cr\[1\].ren2crh.zdel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.ZLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zdel_3.impl1 analog/buflogic.conv.re2cr\[1\].ren2crh.ZLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.zdel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zdel_3.impl2 analog/buflogic.conv.re2cr\[1\].ren2crh.zdel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.ZLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.znbuf.impl analog/buflogic.conv.re2cr\[1\].ren2crh.ZNLD3
+ AVDD VSS analog/CRHB\[0\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zndel_1.impl1 analog/buflogic.conv.re2cr\[1\].ren2crh.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.zndel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zndel_1.impl2 analog/buflogic.conv.re2cr\[1\].ren2crh.zndel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.ZNLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zndel_2.impl1 analog/buflogic.conv.re2cr\[1\].ren2crh.ZNLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.zndel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zndel_2.impl2 analog/buflogic.conv.re2cr\[1\].ren2crh.zndel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.ZNLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zndel_3.impl1 analog/buflogic.conv.re2cr\[1\].ren2crh.ZNLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.zndel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].ren2crh.zndel_3.impl2 analog/buflogic.conv.re2cr\[1\].ren2crh.zndel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].ren2crh.ZNLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.ibuf16.impl RESULT[1]
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.ZL sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.ln1.impl analog/buflogic.conv.re2cr\[1\].rep2crl.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.ZNL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.ln2.impl analog/buflogic.conv.re2cr\[1\].rep2crl.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.ZL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zbuf.impl analog/buflogic.conv.re2cr\[1\].rep2crl.ZLD3
+ AVDD VSS analog/CRL\[0\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zdel_1.impl1 analog/buflogic.conv.re2cr\[1\].rep2crl.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.zdel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zdel_1.impl2 analog/buflogic.conv.re2cr\[1\].rep2crl.zdel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.ZLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zdel_2.impl1 analog/buflogic.conv.re2cr\[1\].rep2crl.ZLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.zdel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zdel_2.impl2 analog/buflogic.conv.re2cr\[1\].rep2crl.zdel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.ZLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zdel_3.impl1 analog/buflogic.conv.re2cr\[1\].rep2crl.ZLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.zdel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zdel_3.impl2 analog/buflogic.conv.re2cr\[1\].rep2crl.zdel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.ZLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.znbuf.impl analog/buflogic.conv.re2cr\[1\].rep2crl.ZNLD3
+ AVDD VSS analog/CRLB\[0\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zndel_1.impl1 analog/buflogic.conv.re2cr\[1\].rep2crl.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.zndel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zndel_1.impl2 analog/buflogic.conv.re2cr\[1\].rep2crl.zndel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.ZNLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zndel_2.impl1 analog/buflogic.conv.re2cr\[1\].rep2crl.ZNLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.zndel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zndel_2.impl2 analog/buflogic.conv.re2cr\[1\].rep2crl.zndel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.ZNLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zndel_3.impl1 analog/buflogic.conv.re2cr\[1\].rep2crl.ZNLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.zndel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[1\].rep2crl.zndel_3.impl2 analog/buflogic.conv.re2cr\[1\].rep2crl.zndel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[1\].rep2crl.ZNLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.ibuf16.impl RESULTN\[2\]
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.ZL sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.ln1.impl analog/buflogic.conv.re2cr\[2\].ren2crh.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.ZNL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.ln2.impl analog/buflogic.conv.re2cr\[2\].ren2crh.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.ZL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zbuf.impl analog/buflogic.conv.re2cr\[2\].ren2crh.ZLD3
+ AVDD VSS analog/CRH\[1\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zdel_1.impl1 analog/buflogic.conv.re2cr\[2\].ren2crh.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.zdel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zdel_1.impl2 analog/buflogic.conv.re2cr\[2\].ren2crh.zdel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.ZLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zdel_2.impl1 analog/buflogic.conv.re2cr\[2\].ren2crh.ZLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.zdel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zdel_2.impl2 analog/buflogic.conv.re2cr\[2\].ren2crh.zdel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.ZLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zdel_3.impl1 analog/buflogic.conv.re2cr\[2\].ren2crh.ZLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.zdel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zdel_3.impl2 analog/buflogic.conv.re2cr\[2\].ren2crh.zdel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.ZLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.znbuf.impl analog/buflogic.conv.re2cr\[2\].ren2crh.ZNLD3
+ AVDD VSS analog/CRHB\[1\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zndel_1.impl1 analog/buflogic.conv.re2cr\[2\].ren2crh.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.zndel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zndel_1.impl2 analog/buflogic.conv.re2cr\[2\].ren2crh.zndel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.ZNLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zndel_2.impl1 analog/buflogic.conv.re2cr\[2\].ren2crh.ZNLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.zndel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zndel_2.impl2 analog/buflogic.conv.re2cr\[2\].ren2crh.zndel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.ZNLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zndel_3.impl1 analog/buflogic.conv.re2cr\[2\].ren2crh.ZNLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.zndel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].ren2crh.zndel_3.impl2 analog/buflogic.conv.re2cr\[2\].ren2crh.zndel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].ren2crh.ZNLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.ibuf16.impl RESULT[2]
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.ZL sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.ln1.impl analog/buflogic.conv.re2cr\[2\].rep2crl.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.ZNL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.ln2.impl analog/buflogic.conv.re2cr\[2\].rep2crl.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.ZL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zbuf.impl analog/buflogic.conv.re2cr\[2\].rep2crl.ZLD3
+ AVDD VSS analog/CRL\[1\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zdel_1.impl1 analog/buflogic.conv.re2cr\[2\].rep2crl.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.zdel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zdel_1.impl2 analog/buflogic.conv.re2cr\[2\].rep2crl.zdel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.ZLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zdel_2.impl1 analog/buflogic.conv.re2cr\[2\].rep2crl.ZLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.zdel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zdel_2.impl2 analog/buflogic.conv.re2cr\[2\].rep2crl.zdel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.ZLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zdel_3.impl1 analog/buflogic.conv.re2cr\[2\].rep2crl.ZLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.zdel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zdel_3.impl2 analog/buflogic.conv.re2cr\[2\].rep2crl.zdel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.ZLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.znbuf.impl analog/buflogic.conv.re2cr\[2\].rep2crl.ZNLD3
+ AVDD VSS analog/CRLB\[1\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zndel_1.impl1 analog/buflogic.conv.re2cr\[2\].rep2crl.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.zndel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zndel_1.impl2 analog/buflogic.conv.re2cr\[2\].rep2crl.zndel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.ZNLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zndel_2.impl1 analog/buflogic.conv.re2cr\[2\].rep2crl.ZNLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.zndel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zndel_2.impl2 analog/buflogic.conv.re2cr\[2\].rep2crl.zndel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.ZNLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zndel_3.impl1 analog/buflogic.conv.re2cr\[2\].rep2crl.ZNLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.zndel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[2\].rep2crl.zndel_3.impl2 analog/buflogic.conv.re2cr\[2\].rep2crl.zndel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[2\].rep2crl.ZNLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.ibuf16.impl RESULTN\[3\]
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.ZL sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.ln1.impl analog/buflogic.conv.re2cr\[3\].ren2crh.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.ZNL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.ln2.impl analog/buflogic.conv.re2cr\[3\].ren2crh.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.ZL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zbuf.impl analog/buflogic.conv.re2cr\[3\].ren2crh.ZLD3
+ AVDD VSS analog/CRH\[2\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zdel_1.impl1 analog/buflogic.conv.re2cr\[3\].ren2crh.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.zdel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zdel_1.impl2 analog/buflogic.conv.re2cr\[3\].ren2crh.zdel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.ZLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zdel_2.impl1 analog/buflogic.conv.re2cr\[3\].ren2crh.ZLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.zdel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zdel_2.impl2 analog/buflogic.conv.re2cr\[3\].ren2crh.zdel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.ZLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zdel_3.impl1 analog/buflogic.conv.re2cr\[3\].ren2crh.ZLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.zdel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zdel_3.impl2 analog/buflogic.conv.re2cr\[3\].ren2crh.zdel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.ZLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.znbuf.impl analog/buflogic.conv.re2cr\[3\].ren2crh.ZNLD3
+ AVDD VSS analog/CRHB\[2\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zndel_1.impl1 analog/buflogic.conv.re2cr\[3\].ren2crh.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.zndel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zndel_1.impl2 analog/buflogic.conv.re2cr\[3\].ren2crh.zndel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.ZNLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zndel_2.impl1 analog/buflogic.conv.re2cr\[3\].ren2crh.ZNLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.zndel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zndel_2.impl2 analog/buflogic.conv.re2cr\[3\].ren2crh.zndel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.ZNLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zndel_3.impl1 analog/buflogic.conv.re2cr\[3\].ren2crh.ZNLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.zndel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].ren2crh.zndel_3.impl2 analog/buflogic.conv.re2cr\[3\].ren2crh.zndel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].ren2crh.ZNLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.ibuf16.impl RESULT[3]
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.ZL sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.ln1.impl analog/buflogic.conv.re2cr\[3\].rep2crl.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.ZNL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.ln2.impl analog/buflogic.conv.re2cr\[3\].rep2crl.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.ZL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zbuf.impl analog/buflogic.conv.re2cr\[3\].rep2crl.ZLD3
+ AVDD VSS analog/CRL\[2\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zdel_1.impl1 analog/buflogic.conv.re2cr\[3\].rep2crl.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.zdel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zdel_1.impl2 analog/buflogic.conv.re2cr\[3\].rep2crl.zdel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.ZLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zdel_2.impl1 analog/buflogic.conv.re2cr\[3\].rep2crl.ZLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.zdel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zdel_2.impl2 analog/buflogic.conv.re2cr\[3\].rep2crl.zdel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.ZLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zdel_3.impl1 analog/buflogic.conv.re2cr\[3\].rep2crl.ZLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.zdel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zdel_3.impl2 analog/buflogic.conv.re2cr\[3\].rep2crl.zdel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.ZLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.znbuf.impl analog/buflogic.conv.re2cr\[3\].rep2crl.ZNLD3
+ AVDD VSS analog/CRLB\[2\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zndel_1.impl1 analog/buflogic.conv.re2cr\[3\].rep2crl.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.zndel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zndel_1.impl2 analog/buflogic.conv.re2cr\[3\].rep2crl.zndel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.ZNLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zndel_2.impl1 analog/buflogic.conv.re2cr\[3\].rep2crl.ZNLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.zndel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zndel_2.impl2 analog/buflogic.conv.re2cr\[3\].rep2crl.zndel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.ZNLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zndel_3.impl1 analog/buflogic.conv.re2cr\[3\].rep2crl.ZNLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.zndel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[3\].rep2crl.zndel_3.impl2 analog/buflogic.conv.re2cr\[3\].rep2crl.zndel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[3\].rep2crl.ZNLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.ibuf16.impl RESULTN\[4\]
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.ZL sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.ln1.impl analog/buflogic.conv.re2cr\[4\].ren2crh.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.ZNL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.ln2.impl analog/buflogic.conv.re2cr\[4\].ren2crh.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.ZL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zbuf.impl analog/buflogic.conv.re2cr\[4\].ren2crh.ZLD3
+ AVDD VSS analog/CRH\[3\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zdel_1.impl1 analog/buflogic.conv.re2cr\[4\].ren2crh.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.zdel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zdel_1.impl2 analog/buflogic.conv.re2cr\[4\].ren2crh.zdel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.ZLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zdel_2.impl1 analog/buflogic.conv.re2cr\[4\].ren2crh.ZLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.zdel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zdel_2.impl2 analog/buflogic.conv.re2cr\[4\].ren2crh.zdel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.ZLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zdel_3.impl1 analog/buflogic.conv.re2cr\[4\].ren2crh.ZLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.zdel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zdel_3.impl2 analog/buflogic.conv.re2cr\[4\].ren2crh.zdel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.ZLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.znbuf.impl analog/buflogic.conv.re2cr\[4\].ren2crh.ZNLD3
+ AVDD VSS analog/CRHB\[3\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zndel_1.impl1 analog/buflogic.conv.re2cr\[4\].ren2crh.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.zndel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zndel_1.impl2 analog/buflogic.conv.re2cr\[4\].ren2crh.zndel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.ZNLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zndel_2.impl1 analog/buflogic.conv.re2cr\[4\].ren2crh.ZNLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.zndel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zndel_2.impl2 analog/buflogic.conv.re2cr\[4\].ren2crh.zndel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.ZNLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zndel_3.impl1 analog/buflogic.conv.re2cr\[4\].ren2crh.ZNLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.zndel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].ren2crh.zndel_3.impl2 analog/buflogic.conv.re2cr\[4\].ren2crh.zndel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].ren2crh.ZNLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.ibuf16.impl RESULT[4]
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.ZL sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.ln1.impl analog/buflogic.conv.re2cr\[4\].rep2crl.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.ZNL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.ln2.impl analog/buflogic.conv.re2cr\[4\].rep2crl.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.ZL sg13g2f_INVD8
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zbuf.impl analog/buflogic.conv.re2cr\[4\].rep2crl.ZLD3
+ AVDD VSS analog/CRL\[3\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zdel_1.impl1 analog/buflogic.conv.re2cr\[4\].rep2crl.ZL
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.zdel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zdel_1.impl2 analog/buflogic.conv.re2cr\[4\].rep2crl.zdel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.ZLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zdel_2.impl1 analog/buflogic.conv.re2cr\[4\].rep2crl.ZLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.zdel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zdel_2.impl2 analog/buflogic.conv.re2cr\[4\].rep2crl.zdel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.ZLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zdel_3.impl1 analog/buflogic.conv.re2cr\[4\].rep2crl.ZLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.zdel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zdel_3.impl2 analog/buflogic.conv.re2cr\[4\].rep2crl.zdel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.ZLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.znbuf.impl analog/buflogic.conv.re2cr\[4\].rep2crl.ZNLD3
+ AVDD VSS analog/CRLB\[3\] sg13g2f_BUFFD16
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zndel_1.impl1 analog/buflogic.conv.re2cr\[4\].rep2crl.ZNL
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.zndel_1.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zndel_1.impl2 analog/buflogic.conv.re2cr\[4\].rep2crl.zndel_1.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.ZNLD1 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zndel_2.impl1 analog/buflogic.conv.re2cr\[4\].rep2crl.ZNLD1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.zndel_2.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zndel_2.impl2 analog/buflogic.conv.re2cr\[4\].rep2crl.zndel_2.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.ZNLD2 sg13g2f_BUFFD2
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zndel_3.impl1 analog/buflogic.conv.re2cr\[4\].rep2crl.ZNLD2
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.zndel_3.Z1
+ sg13g2f_DEL4
Xanalog/buflogic.conv.re2cr\[4\].rep2crl.zndel_3.impl2 analog/buflogic.conv.re2cr\[4\].rep2crl.zndel_3.Z1
+ AVDD VSS analog/buflogic.conv.re2cr\[4\].rep2crl.ZNLD3 sg13g2f_BUFFD2
Xanalog/buflogic.conv.smpcs.choldb.impl analog/buflogic.HOLD
+ AVDD VSS analog/buflogic.conv.smpcs.CHOLDB sg13g2f_INVD8
Xanalog/buflogic.conv.smpcs.choldb1.impl analog/buflogic.conv.smpcs.CHOLDB
+ AVDD VSS analog/buflogic.conv.smpcs.CHOLDB1 sg13g2f_BUFFD8
Xanalog/buflogic.conv.smpcs.clkbuf.impl clknet_1_0__leaf_CLK_regs
+ AVDD VSS CLKBUF sg13g2f_BUFFD16
Xanalog/buflogic.conv.smpcs.clkbufd1.impl1 CLKBUF AVDD VSS
+ analog/buflogic.conv.smpcs.clkbufd1.Z1 sg13g2f_DEL4
Xanalog/buflogic.conv.smpcs.clkbufd1.impl2 analog/buflogic.conv.smpcs.clkbufd1.Z1
+ AVDD VSS analog/buflogic.conv.smpcs.CLKBUFD1 sg13g2f_BUFFD4
Xanalog/buflogic.conv.smpcs.clkbufd2.impl1 analog/buflogic.conv.smpcs.CLKBUFD1
+ AVDD VSS analog/buflogic.conv.smpcs.clkbufd2.Z1 sg13g2f_DEL4
Xanalog/buflogic.conv.smpcs.clkbufd2.impl2 analog/buflogic.conv.smpcs.clkbufd2.Z1
+ AVDD VSS analog/buflogic.conv.smpcs.CLKBUFD2 sg13g2f_BUFFD4
Xanalog/buflogic.conv.smpcs.clkbufd3.impl1 analog/buflogic.conv.smpcs.CLKBUFD2
+ AVDD VSS analog/buflogic.conv.smpcs.clkbufd3.Z1 sg13g2f_DEL4
Xanalog/buflogic.conv.smpcs.clkbufd3.impl2 analog/buflogic.conv.smpcs.clkbufd3.Z1
+ AVDD VSS analog/buflogic.conv.smpcs.CLKBUFD3 sg13g2f_BUFFD4
Xanalog/buflogic.conv.smpcs.cpreand.impl analog/buflogic.conv.smpcs.CHOLDB1
+ analog/buflogic.conv.smpcs.CLKBUFD3 AVDD VSS analog/buflogic.PRE
+ sg13g2f_AN2D4
Xanalog/buflogic.conv.smpcs.invsmp.impl SAMPLE AVDD VSS analog/buflogic.HOLD
+ sg13g2f_INVD8
Xanalog/buflogic.lnbuf_ccmp.del4.impl1 analog/buflogic.CMP
+ AVDD VSS analog/buflogic.lnbuf_ccmp.del4.Z1 sg13g2f_DEL4
Xanalog/buflogic.lnbuf_ccmp.del4.impl2 analog/buflogic.lnbuf_ccmp.del4.Z1
+ AVDD VSS analog/buflogic.lnbuf_ccmp.ID sg13g2f_BUFFD4
Xanalog/buflogic.lnbuf_ccmp.deland.impl analog/buflogic.CMP
+ analog/buflogic.lnbuf_ccmp.ID AVDD VSS analog/buflogic.lnbuf_ccmp.IP
+ sg13g2f_AN2D4
Xanalog/buflogic.lnbuf_ccmp.delbuf16.impl analog/buflogic.lnbuf_ccmp.IP
+ AVDD VSS analog/CCMP sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_ccmp.ln1.impl analog/buflogic.CMP AVDD
+ VSS analog/buflogic.lnbuf_ccmp.IL sg13g2f_INVD6
Xanalog/buflogic.lnbuf_ccmp.ln2.impl analog/buflogic.lnbuf_ccmp.IL
+ AVDD VSS analog/buflogic.CMP sg13g2f_INVD6
Xanalog/buflogic.lnbuf_ccmp.lnbbuf16.impl analog/buflogic.lnbuf_ccmp.ILBUF
+ AVDD VSS analog/CCMPB sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_ccmp.lnbbuf4.impl analog/buflogic.lnbuf_ccmp.IL
+ AVDD VSS analog/buflogic.lnbuf_ccmp.ILBUF sg13g2f_BUFFD4
Xanalog/buflogic.lnbuf_chold.ibuf16.impl analog/buflogic.HOLD
+ AVDD VSS analog/buflogic.lnbuf_chold.N3 sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_chold.ln1.impl analog/buflogic.lnbuf_chold.N3
+ AVDD VSS analog/buflogic.lnbuf_chold.N2 sg13g2f_INVD8
Xanalog/buflogic.lnbuf_chold.ln2.impl analog/buflogic.lnbuf_chold.N2
+ AVDD VSS analog/buflogic.lnbuf_chold.N3 sg13g2f_INVD8
Xanalog/buflogic.lnbuf_chold.zbuf16_1.impl analog/buflogic.lnbuf_chold.N1
+ AVDD VSS analog/CHOLD sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_chold.zbuf16_2.impl analog/buflogic.lnbuf_chold.N1
+ AVDD VSS analog/CHOLD sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_chold.zbuf8.impl analog/buflogic.lnbuf_chold.N3
+ AVDD VSS analog/buflogic.lnbuf_chold.N1 sg13g2f_BUFFD8
Xanalog/buflogic.lnbuf_chold.znbuf16_1.impl analog/buflogic.lnbuf_chold.N2
+ AVDD VSS analog/CHOLDB sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_chold.znbuf16_2.impl analog/buflogic.lnbuf_chold.N2
+ AVDD VSS analog/CHOLDB sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_cpre.ibuf16.impl analog/buflogic.PRE
+ AVDD VSS analog/buflogic.lnbuf_cpre.N3 sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_cpre.ln1.impl analog/buflogic.lnbuf_cpre.N3
+ AVDD VSS analog/buflogic.lnbuf_cpre.N2 sg13g2f_INVD8
Xanalog/buflogic.lnbuf_cpre.ln2.impl analog/buflogic.lnbuf_cpre.N2
+ AVDD VSS analog/buflogic.lnbuf_cpre.N3 sg13g2f_INVD8
Xanalog/buflogic.lnbuf_cpre.zbuf16_1.impl analog/buflogic.lnbuf_cpre.N1
+ AVDD VSS analog/CPRE sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_cpre.zbuf16_2.impl analog/buflogic.lnbuf_cpre.N1
+ AVDD VSS analog/CPRE sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_cpre.zbuf8.impl analog/buflogic.lnbuf_cpre.N3
+ AVDD VSS analog/buflogic.lnbuf_cpre.N1 sg13g2f_BUFFD8
Xanalog/buflogic.lnbuf_cpre.znbuf16_1.impl analog/buflogic.lnbuf_cpre.N2
+ AVDD VSS analog/CPREB sg13g2f_BUFFD16
Xanalog/buflogic.lnbuf_cpre.znbuf16_2.impl analog/buflogic.lnbuf_cpre.N2
+ AVDD VSS analog/CPREB sg13g2f_BUFFD16
Xanalog/cmp.buf_n0.impl analog/cmp.OUTNp AVDD VSS analog/cmp.OUTNpb
+ sg13g2f_BUFFD0
Xanalog/cmp.buf_n1.impl analog/cmp.OUTNpb AVDD VSS analog/cmp.OUTN
+ sg13g2f_BUFFD2
Xanalog/cmp.buf_p0.impl analog/cmp.OUTPp AVDD VSS analog/cmp.OUTPpb
+ sg13g2f_BUFFD0
Xanalog/cmp.buf_p1.impl analog/cmp.OUTPpb AVDD VSS CMPO sg13g2f_BUFFD2
Xanalog/cmp.n2p.impl analog/cmp.OUTNp analog/CCMP AVDD VSS
+ analog/cmp.OUTPp sg13g2f_ND2D2
Xanalog/cmp.p2n.impl analog/cmp.OUTPp analog/CCMP AVDD VSS
+ analog/cmp.OUTNp sg13g2f_ND2D2
Xanalog/cmp.vn_cmp.impl_0 analog/CCMPB analog/VOUTL analog/CCMP
+ analog/cmp.OUTNp AVDD VSS analog/cmp.OUTPp sg13g2f_OAI211D4
Xanalog/cmp.vn_cmp.impl_1 analog/CCMPB analog/VOUTL analog/CCMP
+ analog/cmp.OUTNp AVDD VSS analog/cmp.OUTPp sg13g2f_OAI211D4
Xanalog/cmp.vn_cmp.impl_2 analog/CCMPB analog/VOUTL analog/CCMP
+ analog/cmp.OUTNp AVDD VSS analog/cmp.OUTPp sg13g2f_OAI211D4
Xanalog/cmp.vn_cmp.impl_3 analog/CCMPB analog/VOUTL analog/CCMP
+ analog/cmp.OUTNp AVDD VSS analog/cmp.OUTPp sg13g2f_OAI211D4
Xanalog/cmp.vp_cmp.impl_0 analog/CCMPB analog/VOUTH analog/CCMP
+ analog/cmp.OUTPp AVDD VSS analog/cmp.OUTNp sg13g2f_OAI211D4
Xanalog/cmp.vp_cmp.impl_1 analog/CCMPB analog/VOUTH analog/CCMP
+ analog/cmp.OUTPp AVDD VSS analog/cmp.OUTNp sg13g2f_OAI211D4
Xanalog/cmp.vp_cmp.impl_2 analog/CCMPB analog/VOUTH analog/CCMP
+ analog/cmp.OUTPp AVDD VSS analog/cmp.OUTNp sg13g2f_OAI211D4
Xanalog/cmp.vp_cmp.impl_3 analog/CCMPB analog/VOUTH analog/CCMP
+ analog/cmp.OUTPp AVDD VSS analog/cmp.OUTNp sg13g2f_OAI211D4
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[0\].dummy.VSH
+ analog/dummy_h.dummy\[0\].dummy.VOUTH analog/dummy_h.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[0\].dummy.VOUTH
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[0\].dummy.VOUTH
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[0\].dummy.VSH
+ analog/dummy_h.dummy\[0\].dummy.VOUTH analog/dummy_h.dummy\[0\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[0\].dummy.VSH
+ analog/dummy_h.dummy\[0\].dummy.VOUTL analog/dummy_h.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[0\].dummy.VOUTL
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[0\].dummy.VOUTL
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[0\].dummy.VSH
+ analog/dummy_h.dummy\[0\].dummy.VOUTL analog/dummy_h.dummy\[0\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.FL
+ analog/dummy_h.dummy\[0\].dummy.FL analog/dummy_h.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.FL
+ analog/dummy_h.dummy\[0\].dummy.FL analog/dummy_h.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.FL
+ analog/dummy_h.dummy\[0\].dummy.FL analog/dummy_h.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.FL
+ analog/dummy_h.dummy\[0\].dummy.FL analog/dummy_h.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.FL
+ analog/dummy_h.dummy\[0\].dummy.FL analog/dummy_h.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.FL
+ analog/dummy_h.dummy\[0\].dummy.FL analog/dummy_h.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[0\].dummy.VREF
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[0\].dummy.VSH
+ analog/dummy_h.dummy\[0\].dummy.VREF analog/dummy_h.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[0\].dummy.VSH
+ analog/dummy_h.dummy\[0\].dummy.VREF analog/dummy_h.dummy\[0\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[0\].dummy.VREF
+ analog/dummy_h.dummy\[0\].dummy.VSH analog/dummy_h.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[10\].dummy.VSH
+ analog/dummy_h.dummy\[10\].dummy.VOUTH analog/dummy_h.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[10\].dummy.VOUTH
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[10\].dummy.VOUTH
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[10\].dummy.VSH
+ analog/dummy_h.dummy\[10\].dummy.VOUTH analog/dummy_h.dummy\[10\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[10\].dummy.VSH
+ analog/dummy_h.dummy\[10\].dummy.VOUTL analog/dummy_h.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[10\].dummy.VOUTL
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[10\].dummy.VOUTL
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[10\].dummy.VSH
+ analog/dummy_h.dummy\[10\].dummy.VOUTL analog/dummy_h.dummy\[10\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.FL
+ analog/dummy_h.dummy\[10\].dummy.FL analog/dummy_h.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.FL
+ analog/dummy_h.dummy\[10\].dummy.FL analog/dummy_h.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.FL
+ analog/dummy_h.dummy\[10\].dummy.FL analog/dummy_h.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.FL
+ analog/dummy_h.dummy\[10\].dummy.FL analog/dummy_h.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.FL
+ analog/dummy_h.dummy\[10\].dummy.FL analog/dummy_h.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.FL
+ analog/dummy_h.dummy\[10\].dummy.FL analog/dummy_h.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[10\].dummy.VREF
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[10\].dummy.VSH
+ analog/dummy_h.dummy\[10\].dummy.VREF analog/dummy_h.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[10\].dummy.VSH
+ analog/dummy_h.dummy\[10\].dummy.VREF analog/dummy_h.dummy\[10\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[10\].dummy.VREF
+ analog/dummy_h.dummy\[10\].dummy.VSH analog/dummy_h.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[11\].dummy.VSH
+ analog/dummy_h.dummy\[11\].dummy.VOUTH analog/dummy_h.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[11\].dummy.VOUTH
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[11\].dummy.VOUTH
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[11\].dummy.VSH
+ analog/dummy_h.dummy\[11\].dummy.VOUTH analog/dummy_h.dummy\[11\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[11\].dummy.VSH
+ analog/dummy_h.dummy\[11\].dummy.VOUTL analog/dummy_h.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[11\].dummy.VOUTL
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[11\].dummy.VOUTL
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[11\].dummy.VSH
+ analog/dummy_h.dummy\[11\].dummy.VOUTL analog/dummy_h.dummy\[11\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.FL
+ analog/dummy_h.dummy\[11\].dummy.FL analog/dummy_h.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.FL
+ analog/dummy_h.dummy\[11\].dummy.FL analog/dummy_h.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.FL
+ analog/dummy_h.dummy\[11\].dummy.FL analog/dummy_h.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.FL
+ analog/dummy_h.dummy\[11\].dummy.FL analog/dummy_h.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.FL
+ analog/dummy_h.dummy\[11\].dummy.FL analog/dummy_h.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.FL
+ analog/dummy_h.dummy\[11\].dummy.FL analog/dummy_h.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[11\].dummy.VREF
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[11\].dummy.VSH
+ analog/dummy_h.dummy\[11\].dummy.VREF analog/dummy_h.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[11\].dummy.VSH
+ analog/dummy_h.dummy\[11\].dummy.VREF analog/dummy_h.dummy\[11\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[11\].dummy.VREF
+ analog/dummy_h.dummy\[11\].dummy.VSH analog/dummy_h.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[12\].dummy.VSH
+ analog/dummy_h.dummy\[12\].dummy.VOUTH analog/dummy_h.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[12\].dummy.VOUTH
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[12\].dummy.VOUTH
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[12\].dummy.VSH
+ analog/dummy_h.dummy\[12\].dummy.VOUTH analog/dummy_h.dummy\[12\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[12\].dummy.VSH
+ analog/dummy_h.dummy\[12\].dummy.VOUTL analog/dummy_h.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[12\].dummy.VOUTL
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[12\].dummy.VOUTL
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[12\].dummy.VSH
+ analog/dummy_h.dummy\[12\].dummy.VOUTL analog/dummy_h.dummy\[12\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.FL
+ analog/dummy_h.dummy\[12\].dummy.FL analog/dummy_h.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.FL
+ analog/dummy_h.dummy\[12\].dummy.FL analog/dummy_h.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.FL
+ analog/dummy_h.dummy\[12\].dummy.FL analog/dummy_h.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.FL
+ analog/dummy_h.dummy\[12\].dummy.FL analog/dummy_h.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.FL
+ analog/dummy_h.dummy\[12\].dummy.FL analog/dummy_h.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.FL
+ analog/dummy_h.dummy\[12\].dummy.FL analog/dummy_h.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[12\].dummy.VREF
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[12\].dummy.VSH
+ analog/dummy_h.dummy\[12\].dummy.VREF analog/dummy_h.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[12\].dummy.VSH
+ analog/dummy_h.dummy\[12\].dummy.VREF analog/dummy_h.dummy\[12\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[12\].dummy.VREF
+ analog/dummy_h.dummy\[12\].dummy.VSH analog/dummy_h.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[13\].dummy.VSH
+ analog/dummy_h.dummy\[13\].dummy.VOUTH analog/dummy_h.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[13\].dummy.VOUTH
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[13\].dummy.VOUTH
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[13\].dummy.VSH
+ analog/dummy_h.dummy\[13\].dummy.VOUTH analog/dummy_h.dummy\[13\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[13\].dummy.VSH
+ analog/dummy_h.dummy\[13\].dummy.VOUTL analog/dummy_h.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[13\].dummy.VOUTL
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[13\].dummy.VOUTL
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[13\].dummy.VSH
+ analog/dummy_h.dummy\[13\].dummy.VOUTL analog/dummy_h.dummy\[13\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.FL
+ analog/dummy_h.dummy\[13\].dummy.FL analog/dummy_h.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.FL
+ analog/dummy_h.dummy\[13\].dummy.FL analog/dummy_h.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.FL
+ analog/dummy_h.dummy\[13\].dummy.FL analog/dummy_h.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.FL
+ analog/dummy_h.dummy\[13\].dummy.FL analog/dummy_h.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.FL
+ analog/dummy_h.dummy\[13\].dummy.FL analog/dummy_h.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.FL
+ analog/dummy_h.dummy\[13\].dummy.FL analog/dummy_h.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[13\].dummy.VREF
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[13\].dummy.VSH
+ analog/dummy_h.dummy\[13\].dummy.VREF analog/dummy_h.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[13\].dummy.VSH
+ analog/dummy_h.dummy\[13\].dummy.VREF analog/dummy_h.dummy\[13\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[13\].dummy.VREF
+ analog/dummy_h.dummy\[13\].dummy.VSH analog/dummy_h.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[14\].dummy.VSH
+ analog/dummy_h.dummy\[14\].dummy.VOUTH analog/dummy_h.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[14\].dummy.VOUTH
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[14\].dummy.VOUTH
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[14\].dummy.VSH
+ analog/dummy_h.dummy\[14\].dummy.VOUTH analog/dummy_h.dummy\[14\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[14\].dummy.VSH
+ analog/dummy_h.dummy\[14\].dummy.VOUTL analog/dummy_h.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[14\].dummy.VOUTL
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[14\].dummy.VOUTL
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[14\].dummy.VSH
+ analog/dummy_h.dummy\[14\].dummy.VOUTL analog/dummy_h.dummy\[14\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.FL
+ analog/dummy_h.dummy\[14\].dummy.FL analog/dummy_h.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.FL
+ analog/dummy_h.dummy\[14\].dummy.FL analog/dummy_h.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.FL
+ analog/dummy_h.dummy\[14\].dummy.FL analog/dummy_h.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.FL
+ analog/dummy_h.dummy\[14\].dummy.FL analog/dummy_h.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.FL
+ analog/dummy_h.dummy\[14\].dummy.FL analog/dummy_h.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.FL
+ analog/dummy_h.dummy\[14\].dummy.FL analog/dummy_h.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[14\].dummy.VREF
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[14\].dummy.VSH
+ analog/dummy_h.dummy\[14\].dummy.VREF analog/dummy_h.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[14\].dummy.VSH
+ analog/dummy_h.dummy\[14\].dummy.VREF analog/dummy_h.dummy\[14\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[14\].dummy.VREF
+ analog/dummy_h.dummy\[14\].dummy.VSH analog/dummy_h.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[15\].dummy.VSH
+ analog/dummy_h.dummy\[15\].dummy.VOUTH analog/dummy_h.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[15\].dummy.VOUTH
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[15\].dummy.VOUTH
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[15\].dummy.VSH
+ analog/dummy_h.dummy\[15\].dummy.VOUTH analog/dummy_h.dummy\[15\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[15\].dummy.VSH
+ analog/dummy_h.dummy\[15\].dummy.VOUTL analog/dummy_h.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[15\].dummy.VOUTL
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[15\].dummy.VOUTL
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[15\].dummy.VSH
+ analog/dummy_h.dummy\[15\].dummy.VOUTL analog/dummy_h.dummy\[15\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.FL
+ analog/dummy_h.dummy\[15\].dummy.FL analog/dummy_h.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.FL
+ analog/dummy_h.dummy\[15\].dummy.FL analog/dummy_h.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.FL
+ analog/dummy_h.dummy\[15\].dummy.FL analog/dummy_h.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.FL
+ analog/dummy_h.dummy\[15\].dummy.FL analog/dummy_h.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.FL
+ analog/dummy_h.dummy\[15\].dummy.FL analog/dummy_h.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.FL
+ analog/dummy_h.dummy\[15\].dummy.FL analog/dummy_h.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[15\].dummy.VREF
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[15\].dummy.VSH
+ analog/dummy_h.dummy\[15\].dummy.VREF analog/dummy_h.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[15\].dummy.VSH
+ analog/dummy_h.dummy\[15\].dummy.VREF analog/dummy_h.dummy\[15\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[15\].dummy.VREF
+ analog/dummy_h.dummy\[15\].dummy.VSH analog/dummy_h.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[16\].dummy.VSH
+ analog/dummy_h.dummy\[16\].dummy.VOUTH analog/dummy_h.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[16\].dummy.VOUTH
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[16\].dummy.VOUTH
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[16\].dummy.VSH
+ analog/dummy_h.dummy\[16\].dummy.VOUTH analog/dummy_h.dummy\[16\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[16\].dummy.VSH
+ analog/dummy_h.dummy\[16\].dummy.VOUTL analog/dummy_h.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[16\].dummy.VOUTL
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[16\].dummy.VOUTL
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[16\].dummy.VSH
+ analog/dummy_h.dummy\[16\].dummy.VOUTL analog/dummy_h.dummy\[16\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.FL
+ analog/dummy_h.dummy\[16\].dummy.FL analog/dummy_h.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.FL
+ analog/dummy_h.dummy\[16\].dummy.FL analog/dummy_h.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.FL
+ analog/dummy_h.dummy\[16\].dummy.FL analog/dummy_h.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.FL
+ analog/dummy_h.dummy\[16\].dummy.FL analog/dummy_h.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.FL
+ analog/dummy_h.dummy\[16\].dummy.FL analog/dummy_h.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.FL
+ analog/dummy_h.dummy\[16\].dummy.FL analog/dummy_h.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[16\].dummy.VREF
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[16\].dummy.VSH
+ analog/dummy_h.dummy\[16\].dummy.VREF analog/dummy_h.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[16\].dummy.VSH
+ analog/dummy_h.dummy\[16\].dummy.VREF analog/dummy_h.dummy\[16\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[16\].dummy.VREF
+ analog/dummy_h.dummy\[16\].dummy.VSH analog/dummy_h.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[17\].dummy.VSH
+ analog/dummy_h.dummy\[17\].dummy.VOUTH analog/dummy_h.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[17\].dummy.VOUTH
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[17\].dummy.VOUTH
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[17\].dummy.VSH
+ analog/dummy_h.dummy\[17\].dummy.VOUTH analog/dummy_h.dummy\[17\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[17\].dummy.VSH
+ analog/dummy_h.dummy\[17\].dummy.VOUTL analog/dummy_h.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[17\].dummy.VOUTL
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[17\].dummy.VOUTL
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[17\].dummy.VSH
+ analog/dummy_h.dummy\[17\].dummy.VOUTL analog/dummy_h.dummy\[17\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.FL
+ analog/dummy_h.dummy\[17\].dummy.FL analog/dummy_h.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.FL
+ analog/dummy_h.dummy\[17\].dummy.FL analog/dummy_h.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.FL
+ analog/dummy_h.dummy\[17\].dummy.FL analog/dummy_h.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.FL
+ analog/dummy_h.dummy\[17\].dummy.FL analog/dummy_h.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.FL
+ analog/dummy_h.dummy\[17\].dummy.FL analog/dummy_h.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.FL
+ analog/dummy_h.dummy\[17\].dummy.FL analog/dummy_h.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[17\].dummy.VREF
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[17\].dummy.VSH
+ analog/dummy_h.dummy\[17\].dummy.VREF analog/dummy_h.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[17\].dummy.VSH
+ analog/dummy_h.dummy\[17\].dummy.VREF analog/dummy_h.dummy\[17\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[17\].dummy.VREF
+ analog/dummy_h.dummy\[17\].dummy.VSH analog/dummy_h.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[18\].dummy.VSH
+ analog/dummy_h.dummy\[18\].dummy.VOUTH analog/dummy_h.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[18\].dummy.VOUTH
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[18\].dummy.VOUTH
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[18\].dummy.VSH
+ analog/dummy_h.dummy\[18\].dummy.VOUTH analog/dummy_h.dummy\[18\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[18\].dummy.VSH
+ analog/dummy_h.dummy\[18\].dummy.VOUTL analog/dummy_h.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[18\].dummy.VOUTL
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[18\].dummy.VOUTL
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[18\].dummy.VSH
+ analog/dummy_h.dummy\[18\].dummy.VOUTL analog/dummy_h.dummy\[18\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.FL
+ analog/dummy_h.dummy\[18\].dummy.FL analog/dummy_h.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.FL
+ analog/dummy_h.dummy\[18\].dummy.FL analog/dummy_h.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.FL
+ analog/dummy_h.dummy\[18\].dummy.FL analog/dummy_h.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.FL
+ analog/dummy_h.dummy\[18\].dummy.FL analog/dummy_h.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.FL
+ analog/dummy_h.dummy\[18\].dummy.FL analog/dummy_h.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.FL
+ analog/dummy_h.dummy\[18\].dummy.FL analog/dummy_h.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[18\].dummy.VREF
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[18\].dummy.VSH
+ analog/dummy_h.dummy\[18\].dummy.VREF analog/dummy_h.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[18\].dummy.VSH
+ analog/dummy_h.dummy\[18\].dummy.VREF analog/dummy_h.dummy\[18\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[18\].dummy.VREF
+ analog/dummy_h.dummy\[18\].dummy.VSH analog/dummy_h.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[19\].dummy.VSH
+ analog/dummy_h.dummy\[19\].dummy.VOUTH analog/dummy_h.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[19\].dummy.VOUTH
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[19\].dummy.VOUTH
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[19\].dummy.VSH
+ analog/dummy_h.dummy\[19\].dummy.VOUTH analog/dummy_h.dummy\[19\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[19\].dummy.VSH
+ analog/dummy_h.dummy\[19\].dummy.VOUTL analog/dummy_h.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[19\].dummy.VOUTL
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[19\].dummy.VOUTL
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[19\].dummy.VSH
+ analog/dummy_h.dummy\[19\].dummy.VOUTL analog/dummy_h.dummy\[19\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.FL
+ analog/dummy_h.dummy\[19\].dummy.FL analog/dummy_h.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.FL
+ analog/dummy_h.dummy\[19\].dummy.FL analog/dummy_h.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.FL
+ analog/dummy_h.dummy\[19\].dummy.FL analog/dummy_h.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.FL
+ analog/dummy_h.dummy\[19\].dummy.FL analog/dummy_h.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.FL
+ analog/dummy_h.dummy\[19\].dummy.FL analog/dummy_h.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.FL
+ analog/dummy_h.dummy\[19\].dummy.FL analog/dummy_h.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[19\].dummy.VREF
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[19\].dummy.VSH
+ analog/dummy_h.dummy\[19\].dummy.VREF analog/dummy_h.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[19\].dummy.VSH
+ analog/dummy_h.dummy\[19\].dummy.VREF analog/dummy_h.dummy\[19\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[19\].dummy.VREF
+ analog/dummy_h.dummy\[19\].dummy.VSH analog/dummy_h.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[1\].dummy.VSH
+ analog/dummy_h.dummy\[1\].dummy.VOUTH analog/dummy_h.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[1\].dummy.VOUTH
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[1\].dummy.VOUTH
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[1\].dummy.VSH
+ analog/dummy_h.dummy\[1\].dummy.VOUTH analog/dummy_h.dummy\[1\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[1\].dummy.VSH
+ analog/dummy_h.dummy\[1\].dummy.VOUTL analog/dummy_h.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[1\].dummy.VOUTL
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[1\].dummy.VOUTL
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[1\].dummy.VSH
+ analog/dummy_h.dummy\[1\].dummy.VOUTL analog/dummy_h.dummy\[1\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.FL
+ analog/dummy_h.dummy\[1\].dummy.FL analog/dummy_h.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.FL
+ analog/dummy_h.dummy\[1\].dummy.FL analog/dummy_h.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.FL
+ analog/dummy_h.dummy\[1\].dummy.FL analog/dummy_h.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.FL
+ analog/dummy_h.dummy\[1\].dummy.FL analog/dummy_h.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.FL
+ analog/dummy_h.dummy\[1\].dummy.FL analog/dummy_h.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.FL
+ analog/dummy_h.dummy\[1\].dummy.FL analog/dummy_h.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[1\].dummy.VREF
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[1\].dummy.VSH
+ analog/dummy_h.dummy\[1\].dummy.VREF analog/dummy_h.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[1\].dummy.VSH
+ analog/dummy_h.dummy\[1\].dummy.VREF analog/dummy_h.dummy\[1\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[1\].dummy.VREF
+ analog/dummy_h.dummy\[1\].dummy.VSH analog/dummy_h.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[20\].dummy.VSH
+ analog/dummy_h.dummy\[20\].dummy.VOUTH analog/dummy_h.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[20\].dummy.VOUTH
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[20\].dummy.VOUTH
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[20\].dummy.VSH
+ analog/dummy_h.dummy\[20\].dummy.VOUTH analog/dummy_h.dummy\[20\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[20\].dummy.VSH
+ analog/dummy_h.dummy\[20\].dummy.VOUTL analog/dummy_h.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[20\].dummy.VOUTL
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[20\].dummy.VOUTL
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[20\].dummy.VSH
+ analog/dummy_h.dummy\[20\].dummy.VOUTL analog/dummy_h.dummy\[20\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.FL
+ analog/dummy_h.dummy\[20\].dummy.FL analog/dummy_h.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.FL
+ analog/dummy_h.dummy\[20\].dummy.FL analog/dummy_h.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.FL
+ analog/dummy_h.dummy\[20\].dummy.FL analog/dummy_h.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.FL
+ analog/dummy_h.dummy\[20\].dummy.FL analog/dummy_h.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.FL
+ analog/dummy_h.dummy\[20\].dummy.FL analog/dummy_h.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.FL
+ analog/dummy_h.dummy\[20\].dummy.FL analog/dummy_h.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[20\].dummy.VREF
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[20\].dummy.VSH
+ analog/dummy_h.dummy\[20\].dummy.VREF analog/dummy_h.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[20\].dummy.VSH
+ analog/dummy_h.dummy\[20\].dummy.VREF analog/dummy_h.dummy\[20\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[20\].dummy.VREF
+ analog/dummy_h.dummy\[20\].dummy.VSH analog/dummy_h.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[21\].dummy.VSH
+ analog/dummy_h.dummy\[21\].dummy.VOUTH analog/dummy_h.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[21\].dummy.VOUTH
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[21\].dummy.VOUTH
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[21\].dummy.VSH
+ analog/dummy_h.dummy\[21\].dummy.VOUTH analog/dummy_h.dummy\[21\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[21\].dummy.VSH
+ analog/dummy_h.dummy\[21\].dummy.VOUTL analog/dummy_h.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[21\].dummy.VOUTL
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[21\].dummy.VOUTL
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[21\].dummy.VSH
+ analog/dummy_h.dummy\[21\].dummy.VOUTL analog/dummy_h.dummy\[21\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.FL
+ analog/dummy_h.dummy\[21\].dummy.FL analog/dummy_h.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.FL
+ analog/dummy_h.dummy\[21\].dummy.FL analog/dummy_h.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.FL
+ analog/dummy_h.dummy\[21\].dummy.FL analog/dummy_h.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.FL
+ analog/dummy_h.dummy\[21\].dummy.FL analog/dummy_h.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.FL
+ analog/dummy_h.dummy\[21\].dummy.FL analog/dummy_h.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.FL
+ analog/dummy_h.dummy\[21\].dummy.FL analog/dummy_h.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[21\].dummy.VREF
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[21\].dummy.VSH
+ analog/dummy_h.dummy\[21\].dummy.VREF analog/dummy_h.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[21\].dummy.VSH
+ analog/dummy_h.dummy\[21\].dummy.VREF analog/dummy_h.dummy\[21\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[21\].dummy.VREF
+ analog/dummy_h.dummy\[21\].dummy.VSH analog/dummy_h.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[22\].dummy.VSH
+ analog/dummy_h.dummy\[22\].dummy.VOUTH analog/dummy_h.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[22\].dummy.VOUTH
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[22\].dummy.VOUTH
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[22\].dummy.VSH
+ analog/dummy_h.dummy\[22\].dummy.VOUTH analog/dummy_h.dummy\[22\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[22\].dummy.VSH
+ analog/dummy_h.dummy\[22\].dummy.VOUTL analog/dummy_h.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[22\].dummy.VOUTL
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[22\].dummy.VOUTL
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[22\].dummy.VSH
+ analog/dummy_h.dummy\[22\].dummy.VOUTL analog/dummy_h.dummy\[22\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.FL
+ analog/dummy_h.dummy\[22\].dummy.FL analog/dummy_h.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.FL
+ analog/dummy_h.dummy\[22\].dummy.FL analog/dummy_h.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.FL
+ analog/dummy_h.dummy\[22\].dummy.FL analog/dummy_h.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.FL
+ analog/dummy_h.dummy\[22\].dummy.FL analog/dummy_h.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.FL
+ analog/dummy_h.dummy\[22\].dummy.FL analog/dummy_h.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.FL
+ analog/dummy_h.dummy\[22\].dummy.FL analog/dummy_h.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[22\].dummy.VREF
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[22\].dummy.VSH
+ analog/dummy_h.dummy\[22\].dummy.VREF analog/dummy_h.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[22\].dummy.VSH
+ analog/dummy_h.dummy\[22\].dummy.VREF analog/dummy_h.dummy\[22\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[22\].dummy.VREF
+ analog/dummy_h.dummy\[22\].dummy.VSH analog/dummy_h.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[23\].dummy.VSH
+ analog/dummy_h.dummy\[23\].dummy.VOUTH analog/dummy_h.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[23\].dummy.VOUTH
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[23\].dummy.VOUTH
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[23\].dummy.VSH
+ analog/dummy_h.dummy\[23\].dummy.VOUTH analog/dummy_h.dummy\[23\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[23\].dummy.VSH
+ analog/dummy_h.dummy\[23\].dummy.VOUTL analog/dummy_h.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[23\].dummy.VOUTL
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[23\].dummy.VOUTL
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[23\].dummy.VSH
+ analog/dummy_h.dummy\[23\].dummy.VOUTL analog/dummy_h.dummy\[23\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.FL
+ analog/dummy_h.dummy\[23\].dummy.FL analog/dummy_h.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.FL
+ analog/dummy_h.dummy\[23\].dummy.FL analog/dummy_h.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.FL
+ analog/dummy_h.dummy\[23\].dummy.FL analog/dummy_h.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.FL
+ analog/dummy_h.dummy\[23\].dummy.FL analog/dummy_h.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.FL
+ analog/dummy_h.dummy\[23\].dummy.FL analog/dummy_h.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.FL
+ analog/dummy_h.dummy\[23\].dummy.FL analog/dummy_h.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[23\].dummy.VREF
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[23\].dummy.VSH
+ analog/dummy_h.dummy\[23\].dummy.VREF analog/dummy_h.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[23\].dummy.VSH
+ analog/dummy_h.dummy\[23\].dummy.VREF analog/dummy_h.dummy\[23\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[23\].dummy.VREF
+ analog/dummy_h.dummy\[23\].dummy.VSH analog/dummy_h.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[24\].dummy.VSH
+ analog/dummy_h.dummy\[24\].dummy.VOUTH analog/dummy_h.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[24\].dummy.VOUTH
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[24\].dummy.VOUTH
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[24\].dummy.VSH
+ analog/dummy_h.dummy\[24\].dummy.VOUTH analog/dummy_h.dummy\[24\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[24\].dummy.VSH
+ analog/dummy_h.dummy\[24\].dummy.VOUTL analog/dummy_h.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[24\].dummy.VOUTL
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[24\].dummy.VOUTL
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[24\].dummy.VSH
+ analog/dummy_h.dummy\[24\].dummy.VOUTL analog/dummy_h.dummy\[24\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.FL
+ analog/dummy_h.dummy\[24\].dummy.FL analog/dummy_h.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.FL
+ analog/dummy_h.dummy\[24\].dummy.FL analog/dummy_h.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.FL
+ analog/dummy_h.dummy\[24\].dummy.FL analog/dummy_h.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.FL
+ analog/dummy_h.dummy\[24\].dummy.FL analog/dummy_h.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.FL
+ analog/dummy_h.dummy\[24\].dummy.FL analog/dummy_h.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.FL
+ analog/dummy_h.dummy\[24\].dummy.FL analog/dummy_h.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[24\].dummy.VREF
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[24\].dummy.VSH
+ analog/dummy_h.dummy\[24\].dummy.VREF analog/dummy_h.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[24\].dummy.VSH
+ analog/dummy_h.dummy\[24\].dummy.VREF analog/dummy_h.dummy\[24\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[24\].dummy.VREF
+ analog/dummy_h.dummy\[24\].dummy.VSH analog/dummy_h.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[25\].dummy.VSH
+ analog/dummy_h.dummy\[25\].dummy.VOUTH analog/dummy_h.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[25\].dummy.VOUTH
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[25\].dummy.VOUTH
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[25\].dummy.VSH
+ analog/dummy_h.dummy\[25\].dummy.VOUTH analog/dummy_h.dummy\[25\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[25\].dummy.VSH
+ analog/dummy_h.dummy\[25\].dummy.VOUTL analog/dummy_h.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[25\].dummy.VOUTL
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[25\].dummy.VOUTL
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[25\].dummy.VSH
+ analog/dummy_h.dummy\[25\].dummy.VOUTL analog/dummy_h.dummy\[25\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.FL
+ analog/dummy_h.dummy\[25\].dummy.FL analog/dummy_h.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.FL
+ analog/dummy_h.dummy\[25\].dummy.FL analog/dummy_h.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.FL
+ analog/dummy_h.dummy\[25\].dummy.FL analog/dummy_h.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.FL
+ analog/dummy_h.dummy\[25\].dummy.FL analog/dummy_h.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.FL
+ analog/dummy_h.dummy\[25\].dummy.FL analog/dummy_h.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.FL
+ analog/dummy_h.dummy\[25\].dummy.FL analog/dummy_h.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[25\].dummy.VREF
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[25\].dummy.VSH
+ analog/dummy_h.dummy\[25\].dummy.VREF analog/dummy_h.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[25\].dummy.VSH
+ analog/dummy_h.dummy\[25\].dummy.VREF analog/dummy_h.dummy\[25\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[25\].dummy.VREF
+ analog/dummy_h.dummy\[25\].dummy.VSH analog/dummy_h.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[26\].dummy.VSH
+ analog/dummy_h.dummy\[26\].dummy.VOUTH analog/dummy_h.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[26\].dummy.VOUTH
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[26\].dummy.VOUTH
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[26\].dummy.VSH
+ analog/dummy_h.dummy\[26\].dummy.VOUTH analog/dummy_h.dummy\[26\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[26\].dummy.VSH
+ analog/dummy_h.dummy\[26\].dummy.VOUTL analog/dummy_h.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[26\].dummy.VOUTL
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[26\].dummy.VOUTL
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[26\].dummy.VSH
+ analog/dummy_h.dummy\[26\].dummy.VOUTL analog/dummy_h.dummy\[26\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.FL
+ analog/dummy_h.dummy\[26\].dummy.FL analog/dummy_h.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.FL
+ analog/dummy_h.dummy\[26\].dummy.FL analog/dummy_h.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.FL
+ analog/dummy_h.dummy\[26\].dummy.FL analog/dummy_h.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.FL
+ analog/dummy_h.dummy\[26\].dummy.FL analog/dummy_h.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.FL
+ analog/dummy_h.dummy\[26\].dummy.FL analog/dummy_h.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.FL
+ analog/dummy_h.dummy\[26\].dummy.FL analog/dummy_h.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[26\].dummy.VREF
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[26\].dummy.VSH
+ analog/dummy_h.dummy\[26\].dummy.VREF analog/dummy_h.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[26\].dummy.VSH
+ analog/dummy_h.dummy\[26\].dummy.VREF analog/dummy_h.dummy\[26\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[26\].dummy.VREF
+ analog/dummy_h.dummy\[26\].dummy.VSH analog/dummy_h.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[27\].dummy.VSH
+ analog/dummy_h.dummy\[27\].dummy.VOUTH analog/dummy_h.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[27\].dummy.VOUTH
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[27\].dummy.VOUTH
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[27\].dummy.VSH
+ analog/dummy_h.dummy\[27\].dummy.VOUTH analog/dummy_h.dummy\[27\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[27\].dummy.VSH
+ analog/dummy_h.dummy\[27\].dummy.VOUTL analog/dummy_h.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[27\].dummy.VOUTL
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[27\].dummy.VOUTL
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[27\].dummy.VSH
+ analog/dummy_h.dummy\[27\].dummy.VOUTL analog/dummy_h.dummy\[27\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.FL
+ analog/dummy_h.dummy\[27\].dummy.FL analog/dummy_h.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.FL
+ analog/dummy_h.dummy\[27\].dummy.FL analog/dummy_h.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.FL
+ analog/dummy_h.dummy\[27\].dummy.FL analog/dummy_h.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.FL
+ analog/dummy_h.dummy\[27\].dummy.FL analog/dummy_h.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.FL
+ analog/dummy_h.dummy\[27\].dummy.FL analog/dummy_h.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.FL
+ analog/dummy_h.dummy\[27\].dummy.FL analog/dummy_h.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[27\].dummy.VREF
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[27\].dummy.VSH
+ analog/dummy_h.dummy\[27\].dummy.VREF analog/dummy_h.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[27\].dummy.VSH
+ analog/dummy_h.dummy\[27\].dummy.VREF analog/dummy_h.dummy\[27\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[27\].dummy.VREF
+ analog/dummy_h.dummy\[27\].dummy.VSH analog/dummy_h.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[2\].dummy.VSH
+ analog/dummy_h.dummy\[2\].dummy.VOUTH analog/dummy_h.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[2\].dummy.VOUTH
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[2\].dummy.VOUTH
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[2\].dummy.VSH
+ analog/dummy_h.dummy\[2\].dummy.VOUTH analog/dummy_h.dummy\[2\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[2\].dummy.VSH
+ analog/dummy_h.dummy\[2\].dummy.VOUTL analog/dummy_h.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[2\].dummy.VOUTL
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[2\].dummy.VOUTL
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[2\].dummy.VSH
+ analog/dummy_h.dummy\[2\].dummy.VOUTL analog/dummy_h.dummy\[2\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.FL
+ analog/dummy_h.dummy\[2\].dummy.FL analog/dummy_h.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.FL
+ analog/dummy_h.dummy\[2\].dummy.FL analog/dummy_h.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.FL
+ analog/dummy_h.dummy\[2\].dummy.FL analog/dummy_h.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.FL
+ analog/dummy_h.dummy\[2\].dummy.FL analog/dummy_h.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.FL
+ analog/dummy_h.dummy\[2\].dummy.FL analog/dummy_h.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.FL
+ analog/dummy_h.dummy\[2\].dummy.FL analog/dummy_h.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[2\].dummy.VREF
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[2\].dummy.VSH
+ analog/dummy_h.dummy\[2\].dummy.VREF analog/dummy_h.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[2\].dummy.VSH
+ analog/dummy_h.dummy\[2\].dummy.VREF analog/dummy_h.dummy\[2\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[2\].dummy.VREF
+ analog/dummy_h.dummy\[2\].dummy.VSH analog/dummy_h.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[3\].dummy.VSH
+ analog/dummy_h.dummy\[3\].dummy.VOUTH analog/dummy_h.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[3\].dummy.VOUTH
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[3\].dummy.VOUTH
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[3\].dummy.VSH
+ analog/dummy_h.dummy\[3\].dummy.VOUTH analog/dummy_h.dummy\[3\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[3\].dummy.VSH
+ analog/dummy_h.dummy\[3\].dummy.VOUTL analog/dummy_h.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[3\].dummy.VOUTL
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[3\].dummy.VOUTL
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[3\].dummy.VSH
+ analog/dummy_h.dummy\[3\].dummy.VOUTL analog/dummy_h.dummy\[3\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.FL
+ analog/dummy_h.dummy\[3\].dummy.FL analog/dummy_h.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.FL
+ analog/dummy_h.dummy\[3\].dummy.FL analog/dummy_h.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.FL
+ analog/dummy_h.dummy\[3\].dummy.FL analog/dummy_h.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.FL
+ analog/dummy_h.dummy\[3\].dummy.FL analog/dummy_h.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.FL
+ analog/dummy_h.dummy\[3\].dummy.FL analog/dummy_h.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.FL
+ analog/dummy_h.dummy\[3\].dummy.FL analog/dummy_h.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[3\].dummy.VREF
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[3\].dummy.VSH
+ analog/dummy_h.dummy\[3\].dummy.VREF analog/dummy_h.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[3\].dummy.VSH
+ analog/dummy_h.dummy\[3\].dummy.VREF analog/dummy_h.dummy\[3\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[3\].dummy.VREF
+ analog/dummy_h.dummy\[3\].dummy.VSH analog/dummy_h.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[4\].dummy.VSH
+ analog/dummy_h.dummy\[4\].dummy.VOUTH analog/dummy_h.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[4\].dummy.VOUTH
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[4\].dummy.VOUTH
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[4\].dummy.VSH
+ analog/dummy_h.dummy\[4\].dummy.VOUTH analog/dummy_h.dummy\[4\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[4\].dummy.VSH
+ analog/dummy_h.dummy\[4\].dummy.VOUTL analog/dummy_h.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[4\].dummy.VOUTL
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[4\].dummy.VOUTL
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[4\].dummy.VSH
+ analog/dummy_h.dummy\[4\].dummy.VOUTL analog/dummy_h.dummy\[4\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.FL
+ analog/dummy_h.dummy\[4\].dummy.FL analog/dummy_h.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.FL
+ analog/dummy_h.dummy\[4\].dummy.FL analog/dummy_h.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.FL
+ analog/dummy_h.dummy\[4\].dummy.FL analog/dummy_h.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.FL
+ analog/dummy_h.dummy\[4\].dummy.FL analog/dummy_h.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.FL
+ analog/dummy_h.dummy\[4\].dummy.FL analog/dummy_h.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.FL
+ analog/dummy_h.dummy\[4\].dummy.FL analog/dummy_h.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[4\].dummy.VREF
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[4\].dummy.VSH
+ analog/dummy_h.dummy\[4\].dummy.VREF analog/dummy_h.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[4\].dummy.VSH
+ analog/dummy_h.dummy\[4\].dummy.VREF analog/dummy_h.dummy\[4\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[4\].dummy.VREF
+ analog/dummy_h.dummy\[4\].dummy.VSH analog/dummy_h.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[5\].dummy.VSH
+ analog/dummy_h.dummy\[5\].dummy.VOUTH analog/dummy_h.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[5\].dummy.VOUTH
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[5\].dummy.VOUTH
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[5\].dummy.VSH
+ analog/dummy_h.dummy\[5\].dummy.VOUTH analog/dummy_h.dummy\[5\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[5\].dummy.VSH
+ analog/dummy_h.dummy\[5\].dummy.VOUTL analog/dummy_h.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[5\].dummy.VOUTL
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[5\].dummy.VOUTL
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[5\].dummy.VSH
+ analog/dummy_h.dummy\[5\].dummy.VOUTL analog/dummy_h.dummy\[5\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.FL
+ analog/dummy_h.dummy\[5\].dummy.FL analog/dummy_h.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.FL
+ analog/dummy_h.dummy\[5\].dummy.FL analog/dummy_h.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.FL
+ analog/dummy_h.dummy\[5\].dummy.FL analog/dummy_h.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.FL
+ analog/dummy_h.dummy\[5\].dummy.FL analog/dummy_h.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.FL
+ analog/dummy_h.dummy\[5\].dummy.FL analog/dummy_h.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.FL
+ analog/dummy_h.dummy\[5\].dummy.FL analog/dummy_h.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[5\].dummy.VREF
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[5\].dummy.VSH
+ analog/dummy_h.dummy\[5\].dummy.VREF analog/dummy_h.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[5\].dummy.VSH
+ analog/dummy_h.dummy\[5\].dummy.VREF analog/dummy_h.dummy\[5\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[5\].dummy.VREF
+ analog/dummy_h.dummy\[5\].dummy.VSH analog/dummy_h.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[6\].dummy.VSH
+ analog/dummy_h.dummy\[6\].dummy.VOUTH analog/dummy_h.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[6\].dummy.VOUTH
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[6\].dummy.VOUTH
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[6\].dummy.VSH
+ analog/dummy_h.dummy\[6\].dummy.VOUTH analog/dummy_h.dummy\[6\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[6\].dummy.VSH
+ analog/dummy_h.dummy\[6\].dummy.VOUTL analog/dummy_h.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[6\].dummy.VOUTL
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[6\].dummy.VOUTL
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[6\].dummy.VSH
+ analog/dummy_h.dummy\[6\].dummy.VOUTL analog/dummy_h.dummy\[6\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.FL
+ analog/dummy_h.dummy\[6\].dummy.FL analog/dummy_h.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.FL
+ analog/dummy_h.dummy\[6\].dummy.FL analog/dummy_h.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.FL
+ analog/dummy_h.dummy\[6\].dummy.FL analog/dummy_h.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.FL
+ analog/dummy_h.dummy\[6\].dummy.FL analog/dummy_h.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.FL
+ analog/dummy_h.dummy\[6\].dummy.FL analog/dummy_h.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.FL
+ analog/dummy_h.dummy\[6\].dummy.FL analog/dummy_h.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[6\].dummy.VREF
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[6\].dummy.VSH
+ analog/dummy_h.dummy\[6\].dummy.VREF analog/dummy_h.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[6\].dummy.VSH
+ analog/dummy_h.dummy\[6\].dummy.VREF analog/dummy_h.dummy\[6\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[6\].dummy.VREF
+ analog/dummy_h.dummy\[6\].dummy.VSH analog/dummy_h.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[7\].dummy.VSH
+ analog/dummy_h.dummy\[7\].dummy.VOUTH analog/dummy_h.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[7\].dummy.VOUTH
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[7\].dummy.VOUTH
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[7\].dummy.VSH
+ analog/dummy_h.dummy\[7\].dummy.VOUTH analog/dummy_h.dummy\[7\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[7\].dummy.VSH
+ analog/dummy_h.dummy\[7\].dummy.VOUTL analog/dummy_h.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[7\].dummy.VOUTL
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[7\].dummy.VOUTL
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[7\].dummy.VSH
+ analog/dummy_h.dummy\[7\].dummy.VOUTL analog/dummy_h.dummy\[7\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.FL
+ analog/dummy_h.dummy\[7\].dummy.FL analog/dummy_h.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.FL
+ analog/dummy_h.dummy\[7\].dummy.FL analog/dummy_h.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.FL
+ analog/dummy_h.dummy\[7\].dummy.FL analog/dummy_h.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.FL
+ analog/dummy_h.dummy\[7\].dummy.FL analog/dummy_h.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.FL
+ analog/dummy_h.dummy\[7\].dummy.FL analog/dummy_h.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.FL
+ analog/dummy_h.dummy\[7\].dummy.FL analog/dummy_h.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[7\].dummy.VREF
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[7\].dummy.VSH
+ analog/dummy_h.dummy\[7\].dummy.VREF analog/dummy_h.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[7\].dummy.VSH
+ analog/dummy_h.dummy\[7\].dummy.VREF analog/dummy_h.dummy\[7\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[7\].dummy.VREF
+ analog/dummy_h.dummy\[7\].dummy.VSH analog/dummy_h.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[8\].dummy.VSH
+ analog/dummy_h.dummy\[8\].dummy.VOUTH analog/dummy_h.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[8\].dummy.VOUTH
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[8\].dummy.VOUTH
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[8\].dummy.VSH
+ analog/dummy_h.dummy\[8\].dummy.VOUTH analog/dummy_h.dummy\[8\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[8\].dummy.VSH
+ analog/dummy_h.dummy\[8\].dummy.VOUTL analog/dummy_h.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[8\].dummy.VOUTL
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[8\].dummy.VOUTL
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[8\].dummy.VSH
+ analog/dummy_h.dummy\[8\].dummy.VOUTL analog/dummy_h.dummy\[8\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.FL
+ analog/dummy_h.dummy\[8\].dummy.FL analog/dummy_h.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.FL
+ analog/dummy_h.dummy\[8\].dummy.FL analog/dummy_h.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.FL
+ analog/dummy_h.dummy\[8\].dummy.FL analog/dummy_h.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.FL
+ analog/dummy_h.dummy\[8\].dummy.FL analog/dummy_h.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.FL
+ analog/dummy_h.dummy\[8\].dummy.FL analog/dummy_h.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.FL
+ analog/dummy_h.dummy\[8\].dummy.FL analog/dummy_h.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[8\].dummy.VREF
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[8\].dummy.VSH
+ analog/dummy_h.dummy\[8\].dummy.VREF analog/dummy_h.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[8\].dummy.VSH
+ analog/dummy_h.dummy\[8\].dummy.VREF analog/dummy_h.dummy\[8\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[8\].dummy.VREF
+ analog/dummy_h.dummy\[8\].dummy.VSH analog/dummy_h.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[9\].dummy.VSH
+ analog/dummy_h.dummy\[9\].dummy.VOUTH analog/dummy_h.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[9\].dummy.VOUTH
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[9\].dummy.VOUTH
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[9\].dummy.VSH
+ analog/dummy_h.dummy\[9\].dummy.VOUTH analog/dummy_h.dummy\[9\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[9\].dummy.VSH
+ analog/dummy_h.dummy\[9\].dummy.VOUTL analog/dummy_h.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[9\].dummy.VOUTL
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[9\].dummy.VOUTL
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[9\].dummy.VSH
+ analog/dummy_h.dummy\[9\].dummy.VOUTL analog/dummy_h.dummy\[9\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.FL
+ analog/dummy_h.dummy\[9\].dummy.FL analog/dummy_h.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.FL
+ analog/dummy_h.dummy\[9\].dummy.FL analog/dummy_h.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.FL
+ analog/dummy_h.dummy\[9\].dummy.FL analog/dummy_h.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.FL
+ analog/dummy_h.dummy\[9\].dummy.FL analog/dummy_h.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.FL
+ analog/dummy_h.dummy\[9\].dummy.FL analog/dummy_h.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.FL
+ analog/dummy_h.dummy\[9\].dummy.FL analog/dummy_h.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[9\].dummy.VREF
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRH analog/dummy_h.dummy\[9\].dummy.VSH
+ analog/dummy_h.dummy\[9\].dummy.VREF analog/dummy_h.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[9\].dummy.VSH
+ analog/dummy_h.dummy\[9\].dummy.VREF analog/dummy_h.dummy\[9\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_h.dummy\[0\].dummy.CRHB analog/dummy_h.dummy\[9\].dummy.VREF
+ analog/dummy_h.dummy\[9\].dummy.VSH analog/dummy_h.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_h.tieh.impl AVDD VSS analog/dummy_h.dummy\[0\].dummy.CRHB
+ sg13g2f_TIEH
Xanalog/dummy_h.tiel.impl AVDD VSS analog/dummy_h.dummy\[0\].dummy.CRH
+ sg13g2f_TIEL
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[0\].dummy.VSH
+ analog/dummy_l.dummy\[0\].dummy.VOUTH analog/dummy_l.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[0\].dummy.VOUTH
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[0\].dummy.VOUTH
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[0\].dummy.VSH
+ analog/dummy_l.dummy\[0\].dummy.VOUTH analog/dummy_l.dummy\[0\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[0\].dummy.VSH
+ analog/dummy_l.dummy\[0\].dummy.VOUTL analog/dummy_l.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[0\].dummy.VOUTL
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[0\].dummy.VOUTL
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[0\].dummy.VSH
+ analog/dummy_l.dummy\[0\].dummy.VOUTL analog/dummy_l.dummy\[0\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.FL
+ analog/dummy_l.dummy\[0\].dummy.FL analog/dummy_l.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.FL
+ analog/dummy_l.dummy\[0\].dummy.FL analog/dummy_l.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.FL
+ analog/dummy_l.dummy\[0\].dummy.FL analog/dummy_l.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.FL
+ analog/dummy_l.dummy\[0\].dummy.FL analog/dummy_l.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.FL
+ analog/dummy_l.dummy\[0\].dummy.FL analog/dummy_l.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.FL
+ analog/dummy_l.dummy\[0\].dummy.FL analog/dummy_l.dummy\[0\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[0\].dummy.VREF
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[0\].dummy.VSH
+ analog/dummy_l.dummy\[0\].dummy.VREF analog/dummy_l.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[0\].dummy.VSH
+ analog/dummy_l.dummy\[0\].dummy.VREF analog/dummy_l.dummy\[0\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[0\].dummy.VREF
+ analog/dummy_l.dummy\[0\].dummy.VSH analog/dummy_l.dummy\[0\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[10\].dummy.VSH
+ analog/dummy_l.dummy\[10\].dummy.VOUTH analog/dummy_l.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[10\].dummy.VOUTH
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[10\].dummy.VOUTH
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[10\].dummy.VSH
+ analog/dummy_l.dummy\[10\].dummy.VOUTH analog/dummy_l.dummy\[10\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[10\].dummy.VSH
+ analog/dummy_l.dummy\[10\].dummy.VOUTL analog/dummy_l.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[10\].dummy.VOUTL
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[10\].dummy.VOUTL
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[10\].dummy.VSH
+ analog/dummy_l.dummy\[10\].dummy.VOUTL analog/dummy_l.dummy\[10\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.FL
+ analog/dummy_l.dummy\[10\].dummy.FL analog/dummy_l.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.FL
+ analog/dummy_l.dummy\[10\].dummy.FL analog/dummy_l.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.FL
+ analog/dummy_l.dummy\[10\].dummy.FL analog/dummy_l.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.FL
+ analog/dummy_l.dummy\[10\].dummy.FL analog/dummy_l.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.FL
+ analog/dummy_l.dummy\[10\].dummy.FL analog/dummy_l.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.FL
+ analog/dummy_l.dummy\[10\].dummy.FL analog/dummy_l.dummy\[10\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[10\].dummy.VREF
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[10\].dummy.VSH
+ analog/dummy_l.dummy\[10\].dummy.VREF analog/dummy_l.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[10\].dummy.VSH
+ analog/dummy_l.dummy\[10\].dummy.VREF analog/dummy_l.dummy\[10\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[10\].dummy.VREF
+ analog/dummy_l.dummy\[10\].dummy.VSH analog/dummy_l.dummy\[10\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[11\].dummy.VSH
+ analog/dummy_l.dummy\[11\].dummy.VOUTH analog/dummy_l.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[11\].dummy.VOUTH
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[11\].dummy.VOUTH
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[11\].dummy.VSH
+ analog/dummy_l.dummy\[11\].dummy.VOUTH analog/dummy_l.dummy\[11\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[11\].dummy.VSH
+ analog/dummy_l.dummy\[11\].dummy.VOUTL analog/dummy_l.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[11\].dummy.VOUTL
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[11\].dummy.VOUTL
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[11\].dummy.VSH
+ analog/dummy_l.dummy\[11\].dummy.VOUTL analog/dummy_l.dummy\[11\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.FL
+ analog/dummy_l.dummy\[11\].dummy.FL analog/dummy_l.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.FL
+ analog/dummy_l.dummy\[11\].dummy.FL analog/dummy_l.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.FL
+ analog/dummy_l.dummy\[11\].dummy.FL analog/dummy_l.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.FL
+ analog/dummy_l.dummy\[11\].dummy.FL analog/dummy_l.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.FL
+ analog/dummy_l.dummy\[11\].dummy.FL analog/dummy_l.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.FL
+ analog/dummy_l.dummy\[11\].dummy.FL analog/dummy_l.dummy\[11\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[11\].dummy.VREF
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[11\].dummy.VSH
+ analog/dummy_l.dummy\[11\].dummy.VREF analog/dummy_l.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[11\].dummy.VSH
+ analog/dummy_l.dummy\[11\].dummy.VREF analog/dummy_l.dummy\[11\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[11\].dummy.VREF
+ analog/dummy_l.dummy\[11\].dummy.VSH analog/dummy_l.dummy\[11\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[12\].dummy.VSH
+ analog/dummy_l.dummy\[12\].dummy.VOUTH analog/dummy_l.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[12\].dummy.VOUTH
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[12\].dummy.VOUTH
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[12\].dummy.VSH
+ analog/dummy_l.dummy\[12\].dummy.VOUTH analog/dummy_l.dummy\[12\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[12\].dummy.VSH
+ analog/dummy_l.dummy\[12\].dummy.VOUTL analog/dummy_l.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[12\].dummy.VOUTL
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[12\].dummy.VOUTL
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[12\].dummy.VSH
+ analog/dummy_l.dummy\[12\].dummy.VOUTL analog/dummy_l.dummy\[12\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.FL
+ analog/dummy_l.dummy\[12\].dummy.FL analog/dummy_l.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.FL
+ analog/dummy_l.dummy\[12\].dummy.FL analog/dummy_l.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.FL
+ analog/dummy_l.dummy\[12\].dummy.FL analog/dummy_l.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.FL
+ analog/dummy_l.dummy\[12\].dummy.FL analog/dummy_l.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.FL
+ analog/dummy_l.dummy\[12\].dummy.FL analog/dummy_l.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.FL
+ analog/dummy_l.dummy\[12\].dummy.FL analog/dummy_l.dummy\[12\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[12\].dummy.VREF
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[12\].dummy.VSH
+ analog/dummy_l.dummy\[12\].dummy.VREF analog/dummy_l.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[12\].dummy.VSH
+ analog/dummy_l.dummy\[12\].dummy.VREF analog/dummy_l.dummy\[12\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[12\].dummy.VREF
+ analog/dummy_l.dummy\[12\].dummy.VSH analog/dummy_l.dummy\[12\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[13\].dummy.VSH
+ analog/dummy_l.dummy\[13\].dummy.VOUTH analog/dummy_l.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[13\].dummy.VOUTH
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[13\].dummy.VOUTH
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[13\].dummy.VSH
+ analog/dummy_l.dummy\[13\].dummy.VOUTH analog/dummy_l.dummy\[13\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[13\].dummy.VSH
+ analog/dummy_l.dummy\[13\].dummy.VOUTL analog/dummy_l.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[13\].dummy.VOUTL
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[13\].dummy.VOUTL
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[13\].dummy.VSH
+ analog/dummy_l.dummy\[13\].dummy.VOUTL analog/dummy_l.dummy\[13\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.FL
+ analog/dummy_l.dummy\[13\].dummy.FL analog/dummy_l.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.FL
+ analog/dummy_l.dummy\[13\].dummy.FL analog/dummy_l.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.FL
+ analog/dummy_l.dummy\[13\].dummy.FL analog/dummy_l.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.FL
+ analog/dummy_l.dummy\[13\].dummy.FL analog/dummy_l.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.FL
+ analog/dummy_l.dummy\[13\].dummy.FL analog/dummy_l.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.FL
+ analog/dummy_l.dummy\[13\].dummy.FL analog/dummy_l.dummy\[13\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[13\].dummy.VREF
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[13\].dummy.VSH
+ analog/dummy_l.dummy\[13\].dummy.VREF analog/dummy_l.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[13\].dummy.VSH
+ analog/dummy_l.dummy\[13\].dummy.VREF analog/dummy_l.dummy\[13\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[13\].dummy.VREF
+ analog/dummy_l.dummy\[13\].dummy.VSH analog/dummy_l.dummy\[13\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[14\].dummy.VSH
+ analog/dummy_l.dummy\[14\].dummy.VOUTH analog/dummy_l.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[14\].dummy.VOUTH
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[14\].dummy.VOUTH
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[14\].dummy.VSH
+ analog/dummy_l.dummy\[14\].dummy.VOUTH analog/dummy_l.dummy\[14\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[14\].dummy.VSH
+ analog/dummy_l.dummy\[14\].dummy.VOUTL analog/dummy_l.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[14\].dummy.VOUTL
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[14\].dummy.VOUTL
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[14\].dummy.VSH
+ analog/dummy_l.dummy\[14\].dummy.VOUTL analog/dummy_l.dummy\[14\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.FL
+ analog/dummy_l.dummy\[14\].dummy.FL analog/dummy_l.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.FL
+ analog/dummy_l.dummy\[14\].dummy.FL analog/dummy_l.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.FL
+ analog/dummy_l.dummy\[14\].dummy.FL analog/dummy_l.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.FL
+ analog/dummy_l.dummy\[14\].dummy.FL analog/dummy_l.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.FL
+ analog/dummy_l.dummy\[14\].dummy.FL analog/dummy_l.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.FL
+ analog/dummy_l.dummy\[14\].dummy.FL analog/dummy_l.dummy\[14\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[14\].dummy.VREF
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[14\].dummy.VSH
+ analog/dummy_l.dummy\[14\].dummy.VREF analog/dummy_l.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[14\].dummy.VSH
+ analog/dummy_l.dummy\[14\].dummy.VREF analog/dummy_l.dummy\[14\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[14\].dummy.VREF
+ analog/dummy_l.dummy\[14\].dummy.VSH analog/dummy_l.dummy\[14\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[15\].dummy.VSH
+ analog/dummy_l.dummy\[15\].dummy.VOUTH analog/dummy_l.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[15\].dummy.VOUTH
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[15\].dummy.VOUTH
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[15\].dummy.VSH
+ analog/dummy_l.dummy\[15\].dummy.VOUTH analog/dummy_l.dummy\[15\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[15\].dummy.VSH
+ analog/dummy_l.dummy\[15\].dummy.VOUTL analog/dummy_l.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[15\].dummy.VOUTL
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[15\].dummy.VOUTL
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[15\].dummy.VSH
+ analog/dummy_l.dummy\[15\].dummy.VOUTL analog/dummy_l.dummy\[15\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.FL
+ analog/dummy_l.dummy\[15\].dummy.FL analog/dummy_l.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.FL
+ analog/dummy_l.dummy\[15\].dummy.FL analog/dummy_l.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.FL
+ analog/dummy_l.dummy\[15\].dummy.FL analog/dummy_l.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.FL
+ analog/dummy_l.dummy\[15\].dummy.FL analog/dummy_l.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.FL
+ analog/dummy_l.dummy\[15\].dummy.FL analog/dummy_l.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.FL
+ analog/dummy_l.dummy\[15\].dummy.FL analog/dummy_l.dummy\[15\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[15\].dummy.VREF
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[15\].dummy.VSH
+ analog/dummy_l.dummy\[15\].dummy.VREF analog/dummy_l.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[15\].dummy.VSH
+ analog/dummy_l.dummy\[15\].dummy.VREF analog/dummy_l.dummy\[15\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[15\].dummy.VREF
+ analog/dummy_l.dummy\[15\].dummy.VSH analog/dummy_l.dummy\[15\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[16\].dummy.VSH
+ analog/dummy_l.dummy\[16\].dummy.VOUTH analog/dummy_l.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[16\].dummy.VOUTH
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[16\].dummy.VOUTH
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[16\].dummy.VSH
+ analog/dummy_l.dummy\[16\].dummy.VOUTH analog/dummy_l.dummy\[16\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[16\].dummy.VSH
+ analog/dummy_l.dummy\[16\].dummy.VOUTL analog/dummy_l.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[16\].dummy.VOUTL
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[16\].dummy.VOUTL
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[16\].dummy.VSH
+ analog/dummy_l.dummy\[16\].dummy.VOUTL analog/dummy_l.dummy\[16\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.FL
+ analog/dummy_l.dummy\[16\].dummy.FL analog/dummy_l.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.FL
+ analog/dummy_l.dummy\[16\].dummy.FL analog/dummy_l.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.FL
+ analog/dummy_l.dummy\[16\].dummy.FL analog/dummy_l.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.FL
+ analog/dummy_l.dummy\[16\].dummy.FL analog/dummy_l.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.FL
+ analog/dummy_l.dummy\[16\].dummy.FL analog/dummy_l.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.FL
+ analog/dummy_l.dummy\[16\].dummy.FL analog/dummy_l.dummy\[16\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[16\].dummy.VREF
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[16\].dummy.VSH
+ analog/dummy_l.dummy\[16\].dummy.VREF analog/dummy_l.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[16\].dummy.VSH
+ analog/dummy_l.dummy\[16\].dummy.VREF analog/dummy_l.dummy\[16\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[16\].dummy.VREF
+ analog/dummy_l.dummy\[16\].dummy.VSH analog/dummy_l.dummy\[16\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[17\].dummy.VSH
+ analog/dummy_l.dummy\[17\].dummy.VOUTH analog/dummy_l.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[17\].dummy.VOUTH
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[17\].dummy.VOUTH
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[17\].dummy.VSH
+ analog/dummy_l.dummy\[17\].dummy.VOUTH analog/dummy_l.dummy\[17\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[17\].dummy.VSH
+ analog/dummy_l.dummy\[17\].dummy.VOUTL analog/dummy_l.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[17\].dummy.VOUTL
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[17\].dummy.VOUTL
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[17\].dummy.VSH
+ analog/dummy_l.dummy\[17\].dummy.VOUTL analog/dummy_l.dummy\[17\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.FL
+ analog/dummy_l.dummy\[17\].dummy.FL analog/dummy_l.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.FL
+ analog/dummy_l.dummy\[17\].dummy.FL analog/dummy_l.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.FL
+ analog/dummy_l.dummy\[17\].dummy.FL analog/dummy_l.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.FL
+ analog/dummy_l.dummy\[17\].dummy.FL analog/dummy_l.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.FL
+ analog/dummy_l.dummy\[17\].dummy.FL analog/dummy_l.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.FL
+ analog/dummy_l.dummy\[17\].dummy.FL analog/dummy_l.dummy\[17\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[17\].dummy.VREF
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[17\].dummy.VSH
+ analog/dummy_l.dummy\[17\].dummy.VREF analog/dummy_l.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[17\].dummy.VSH
+ analog/dummy_l.dummy\[17\].dummy.VREF analog/dummy_l.dummy\[17\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[17\].dummy.VREF
+ analog/dummy_l.dummy\[17\].dummy.VSH analog/dummy_l.dummy\[17\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[18\].dummy.VSH
+ analog/dummy_l.dummy\[18\].dummy.VOUTH analog/dummy_l.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[18\].dummy.VOUTH
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[18\].dummy.VOUTH
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[18\].dummy.VSH
+ analog/dummy_l.dummy\[18\].dummy.VOUTH analog/dummy_l.dummy\[18\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[18\].dummy.VSH
+ analog/dummy_l.dummy\[18\].dummy.VOUTL analog/dummy_l.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[18\].dummy.VOUTL
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[18\].dummy.VOUTL
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[18\].dummy.VSH
+ analog/dummy_l.dummy\[18\].dummy.VOUTL analog/dummy_l.dummy\[18\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.FL
+ analog/dummy_l.dummy\[18\].dummy.FL analog/dummy_l.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.FL
+ analog/dummy_l.dummy\[18\].dummy.FL analog/dummy_l.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.FL
+ analog/dummy_l.dummy\[18\].dummy.FL analog/dummy_l.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.FL
+ analog/dummy_l.dummy\[18\].dummy.FL analog/dummy_l.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.FL
+ analog/dummy_l.dummy\[18\].dummy.FL analog/dummy_l.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.FL
+ analog/dummy_l.dummy\[18\].dummy.FL analog/dummy_l.dummy\[18\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[18\].dummy.VREF
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[18\].dummy.VSH
+ analog/dummy_l.dummy\[18\].dummy.VREF analog/dummy_l.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[18\].dummy.VSH
+ analog/dummy_l.dummy\[18\].dummy.VREF analog/dummy_l.dummy\[18\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[18\].dummy.VREF
+ analog/dummy_l.dummy\[18\].dummy.VSH analog/dummy_l.dummy\[18\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[19\].dummy.VSH
+ analog/dummy_l.dummy\[19\].dummy.VOUTH analog/dummy_l.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[19\].dummy.VOUTH
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[19\].dummy.VOUTH
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[19\].dummy.VSH
+ analog/dummy_l.dummy\[19\].dummy.VOUTH analog/dummy_l.dummy\[19\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[19\].dummy.VSH
+ analog/dummy_l.dummy\[19\].dummy.VOUTL analog/dummy_l.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[19\].dummy.VOUTL
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[19\].dummy.VOUTL
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[19\].dummy.VSH
+ analog/dummy_l.dummy\[19\].dummy.VOUTL analog/dummy_l.dummy\[19\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.FL
+ analog/dummy_l.dummy\[19\].dummy.FL analog/dummy_l.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.FL
+ analog/dummy_l.dummy\[19\].dummy.FL analog/dummy_l.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.FL
+ analog/dummy_l.dummy\[19\].dummy.FL analog/dummy_l.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.FL
+ analog/dummy_l.dummy\[19\].dummy.FL analog/dummy_l.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.FL
+ analog/dummy_l.dummy\[19\].dummy.FL analog/dummy_l.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.FL
+ analog/dummy_l.dummy\[19\].dummy.FL analog/dummy_l.dummy\[19\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[19\].dummy.VREF
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[19\].dummy.VSH
+ analog/dummy_l.dummy\[19\].dummy.VREF analog/dummy_l.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[19\].dummy.VSH
+ analog/dummy_l.dummy\[19\].dummy.VREF analog/dummy_l.dummy\[19\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[19\].dummy.VREF
+ analog/dummy_l.dummy\[19\].dummy.VSH analog/dummy_l.dummy\[19\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[1\].dummy.VSH
+ analog/dummy_l.dummy\[1\].dummy.VOUTH analog/dummy_l.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[1\].dummy.VOUTH
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[1\].dummy.VOUTH
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[1\].dummy.VSH
+ analog/dummy_l.dummy\[1\].dummy.VOUTH analog/dummy_l.dummy\[1\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[1\].dummy.VSH
+ analog/dummy_l.dummy\[1\].dummy.VOUTL analog/dummy_l.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[1\].dummy.VOUTL
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[1\].dummy.VOUTL
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[1\].dummy.VSH
+ analog/dummy_l.dummy\[1\].dummy.VOUTL analog/dummy_l.dummy\[1\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.FL
+ analog/dummy_l.dummy\[1\].dummy.FL analog/dummy_l.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.FL
+ analog/dummy_l.dummy\[1\].dummy.FL analog/dummy_l.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.FL
+ analog/dummy_l.dummy\[1\].dummy.FL analog/dummy_l.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.FL
+ analog/dummy_l.dummy\[1\].dummy.FL analog/dummy_l.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.FL
+ analog/dummy_l.dummy\[1\].dummy.FL analog/dummy_l.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.FL
+ analog/dummy_l.dummy\[1\].dummy.FL analog/dummy_l.dummy\[1\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[1\].dummy.VREF
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[1\].dummy.VSH
+ analog/dummy_l.dummy\[1\].dummy.VREF analog/dummy_l.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[1\].dummy.VSH
+ analog/dummy_l.dummy\[1\].dummy.VREF analog/dummy_l.dummy\[1\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[1\].dummy.VREF
+ analog/dummy_l.dummy\[1\].dummy.VSH analog/dummy_l.dummy\[1\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[20\].dummy.VSH
+ analog/dummy_l.dummy\[20\].dummy.VOUTH analog/dummy_l.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[20\].dummy.VOUTH
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[20\].dummy.VOUTH
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[20\].dummy.VSH
+ analog/dummy_l.dummy\[20\].dummy.VOUTH analog/dummy_l.dummy\[20\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[20\].dummy.VSH
+ analog/dummy_l.dummy\[20\].dummy.VOUTL analog/dummy_l.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[20\].dummy.VOUTL
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[20\].dummy.VOUTL
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[20\].dummy.VSH
+ analog/dummy_l.dummy\[20\].dummy.VOUTL analog/dummy_l.dummy\[20\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.FL
+ analog/dummy_l.dummy\[20\].dummy.FL analog/dummy_l.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.FL
+ analog/dummy_l.dummy\[20\].dummy.FL analog/dummy_l.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.FL
+ analog/dummy_l.dummy\[20\].dummy.FL analog/dummy_l.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.FL
+ analog/dummy_l.dummy\[20\].dummy.FL analog/dummy_l.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.FL
+ analog/dummy_l.dummy\[20\].dummy.FL analog/dummy_l.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.FL
+ analog/dummy_l.dummy\[20\].dummy.FL analog/dummy_l.dummy\[20\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[20\].dummy.VREF
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[20\].dummy.VSH
+ analog/dummy_l.dummy\[20\].dummy.VREF analog/dummy_l.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[20\].dummy.VSH
+ analog/dummy_l.dummy\[20\].dummy.VREF analog/dummy_l.dummy\[20\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[20\].dummy.VREF
+ analog/dummy_l.dummy\[20\].dummy.VSH analog/dummy_l.dummy\[20\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[21\].dummy.VSH
+ analog/dummy_l.dummy\[21\].dummy.VOUTH analog/dummy_l.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[21\].dummy.VOUTH
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[21\].dummy.VOUTH
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[21\].dummy.VSH
+ analog/dummy_l.dummy\[21\].dummy.VOUTH analog/dummy_l.dummy\[21\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[21\].dummy.VSH
+ analog/dummy_l.dummy\[21\].dummy.VOUTL analog/dummy_l.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[21\].dummy.VOUTL
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[21\].dummy.VOUTL
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[21\].dummy.VSH
+ analog/dummy_l.dummy\[21\].dummy.VOUTL analog/dummy_l.dummy\[21\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.FL
+ analog/dummy_l.dummy\[21\].dummy.FL analog/dummy_l.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.FL
+ analog/dummy_l.dummy\[21\].dummy.FL analog/dummy_l.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.FL
+ analog/dummy_l.dummy\[21\].dummy.FL analog/dummy_l.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.FL
+ analog/dummy_l.dummy\[21\].dummy.FL analog/dummy_l.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.FL
+ analog/dummy_l.dummy\[21\].dummy.FL analog/dummy_l.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.FL
+ analog/dummy_l.dummy\[21\].dummy.FL analog/dummy_l.dummy\[21\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[21\].dummy.VREF
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[21\].dummy.VSH
+ analog/dummy_l.dummy\[21\].dummy.VREF analog/dummy_l.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[21\].dummy.VSH
+ analog/dummy_l.dummy\[21\].dummy.VREF analog/dummy_l.dummy\[21\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[21\].dummy.VREF
+ analog/dummy_l.dummy\[21\].dummy.VSH analog/dummy_l.dummy\[21\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[22\].dummy.VSH
+ analog/dummy_l.dummy\[22\].dummy.VOUTH analog/dummy_l.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[22\].dummy.VOUTH
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[22\].dummy.VOUTH
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[22\].dummy.VSH
+ analog/dummy_l.dummy\[22\].dummy.VOUTH analog/dummy_l.dummy\[22\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[22\].dummy.VSH
+ analog/dummy_l.dummy\[22\].dummy.VOUTL analog/dummy_l.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[22\].dummy.VOUTL
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[22\].dummy.VOUTL
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[22\].dummy.VSH
+ analog/dummy_l.dummy\[22\].dummy.VOUTL analog/dummy_l.dummy\[22\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.FL
+ analog/dummy_l.dummy\[22\].dummy.FL analog/dummy_l.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.FL
+ analog/dummy_l.dummy\[22\].dummy.FL analog/dummy_l.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.FL
+ analog/dummy_l.dummy\[22\].dummy.FL analog/dummy_l.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.FL
+ analog/dummy_l.dummy\[22\].dummy.FL analog/dummy_l.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.FL
+ analog/dummy_l.dummy\[22\].dummy.FL analog/dummy_l.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.FL
+ analog/dummy_l.dummy\[22\].dummy.FL analog/dummy_l.dummy\[22\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[22\].dummy.VREF
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[22\].dummy.VSH
+ analog/dummy_l.dummy\[22\].dummy.VREF analog/dummy_l.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[22\].dummy.VSH
+ analog/dummy_l.dummy\[22\].dummy.VREF analog/dummy_l.dummy\[22\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[22\].dummy.VREF
+ analog/dummy_l.dummy\[22\].dummy.VSH analog/dummy_l.dummy\[22\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[23\].dummy.VSH
+ analog/dummy_l.dummy\[23\].dummy.VOUTH analog/dummy_l.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[23\].dummy.VOUTH
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[23\].dummy.VOUTH
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[23\].dummy.VSH
+ analog/dummy_l.dummy\[23\].dummy.VOUTH analog/dummy_l.dummy\[23\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[23\].dummy.VSH
+ analog/dummy_l.dummy\[23\].dummy.VOUTL analog/dummy_l.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[23\].dummy.VOUTL
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[23\].dummy.VOUTL
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[23\].dummy.VSH
+ analog/dummy_l.dummy\[23\].dummy.VOUTL analog/dummy_l.dummy\[23\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.FL
+ analog/dummy_l.dummy\[23\].dummy.FL analog/dummy_l.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.FL
+ analog/dummy_l.dummy\[23\].dummy.FL analog/dummy_l.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.FL
+ analog/dummy_l.dummy\[23\].dummy.FL analog/dummy_l.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.FL
+ analog/dummy_l.dummy\[23\].dummy.FL analog/dummy_l.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.FL
+ analog/dummy_l.dummy\[23\].dummy.FL analog/dummy_l.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.FL
+ analog/dummy_l.dummy\[23\].dummy.FL analog/dummy_l.dummy\[23\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[23\].dummy.VREF
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[23\].dummy.VSH
+ analog/dummy_l.dummy\[23\].dummy.VREF analog/dummy_l.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[23\].dummy.VSH
+ analog/dummy_l.dummy\[23\].dummy.VREF analog/dummy_l.dummy\[23\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[23\].dummy.VREF
+ analog/dummy_l.dummy\[23\].dummy.VSH analog/dummy_l.dummy\[23\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[24\].dummy.VSH
+ analog/dummy_l.dummy\[24\].dummy.VOUTH analog/dummy_l.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[24\].dummy.VOUTH
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[24\].dummy.VOUTH
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[24\].dummy.VSH
+ analog/dummy_l.dummy\[24\].dummy.VOUTH analog/dummy_l.dummy\[24\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[24\].dummy.VSH
+ analog/dummy_l.dummy\[24\].dummy.VOUTL analog/dummy_l.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[24\].dummy.VOUTL
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[24\].dummy.VOUTL
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[24\].dummy.VSH
+ analog/dummy_l.dummy\[24\].dummy.VOUTL analog/dummy_l.dummy\[24\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.FL
+ analog/dummy_l.dummy\[24\].dummy.FL analog/dummy_l.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.FL
+ analog/dummy_l.dummy\[24\].dummy.FL analog/dummy_l.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.FL
+ analog/dummy_l.dummy\[24\].dummy.FL analog/dummy_l.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.FL
+ analog/dummy_l.dummy\[24\].dummy.FL analog/dummy_l.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.FL
+ analog/dummy_l.dummy\[24\].dummy.FL analog/dummy_l.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.FL
+ analog/dummy_l.dummy\[24\].dummy.FL analog/dummy_l.dummy\[24\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[24\].dummy.VREF
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[24\].dummy.VSH
+ analog/dummy_l.dummy\[24\].dummy.VREF analog/dummy_l.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[24\].dummy.VSH
+ analog/dummy_l.dummy\[24\].dummy.VREF analog/dummy_l.dummy\[24\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[24\].dummy.VREF
+ analog/dummy_l.dummy\[24\].dummy.VSH analog/dummy_l.dummy\[24\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[25\].dummy.VSH
+ analog/dummy_l.dummy\[25\].dummy.VOUTH analog/dummy_l.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[25\].dummy.VOUTH
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[25\].dummy.VOUTH
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[25\].dummy.VSH
+ analog/dummy_l.dummy\[25\].dummy.VOUTH analog/dummy_l.dummy\[25\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[25\].dummy.VSH
+ analog/dummy_l.dummy\[25\].dummy.VOUTL analog/dummy_l.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[25\].dummy.VOUTL
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[25\].dummy.VOUTL
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[25\].dummy.VSH
+ analog/dummy_l.dummy\[25\].dummy.VOUTL analog/dummy_l.dummy\[25\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.FL
+ analog/dummy_l.dummy\[25\].dummy.FL analog/dummy_l.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.FL
+ analog/dummy_l.dummy\[25\].dummy.FL analog/dummy_l.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.FL
+ analog/dummy_l.dummy\[25\].dummy.FL analog/dummy_l.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.FL
+ analog/dummy_l.dummy\[25\].dummy.FL analog/dummy_l.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.FL
+ analog/dummy_l.dummy\[25\].dummy.FL analog/dummy_l.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.FL
+ analog/dummy_l.dummy\[25\].dummy.FL analog/dummy_l.dummy\[25\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[25\].dummy.VREF
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[25\].dummy.VSH
+ analog/dummy_l.dummy\[25\].dummy.VREF analog/dummy_l.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[25\].dummy.VSH
+ analog/dummy_l.dummy\[25\].dummy.VREF analog/dummy_l.dummy\[25\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[25\].dummy.VREF
+ analog/dummy_l.dummy\[25\].dummy.VSH analog/dummy_l.dummy\[25\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[26\].dummy.VSH
+ analog/dummy_l.dummy\[26\].dummy.VOUTH analog/dummy_l.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[26\].dummy.VOUTH
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[26\].dummy.VOUTH
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[26\].dummy.VSH
+ analog/dummy_l.dummy\[26\].dummy.VOUTH analog/dummy_l.dummy\[26\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[26\].dummy.VSH
+ analog/dummy_l.dummy\[26\].dummy.VOUTL analog/dummy_l.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[26\].dummy.VOUTL
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[26\].dummy.VOUTL
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[26\].dummy.VSH
+ analog/dummy_l.dummy\[26\].dummy.VOUTL analog/dummy_l.dummy\[26\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.FL
+ analog/dummy_l.dummy\[26\].dummy.FL analog/dummy_l.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.FL
+ analog/dummy_l.dummy\[26\].dummy.FL analog/dummy_l.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.FL
+ analog/dummy_l.dummy\[26\].dummy.FL analog/dummy_l.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.FL
+ analog/dummy_l.dummy\[26\].dummy.FL analog/dummy_l.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.FL
+ analog/dummy_l.dummy\[26\].dummy.FL analog/dummy_l.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.FL
+ analog/dummy_l.dummy\[26\].dummy.FL analog/dummy_l.dummy\[26\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[26\].dummy.VREF
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[26\].dummy.VSH
+ analog/dummy_l.dummy\[26\].dummy.VREF analog/dummy_l.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[26\].dummy.VSH
+ analog/dummy_l.dummy\[26\].dummy.VREF analog/dummy_l.dummy\[26\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[26\].dummy.VREF
+ analog/dummy_l.dummy\[26\].dummy.VSH analog/dummy_l.dummy\[26\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[27\].dummy.VSH
+ analog/dummy_l.dummy\[27\].dummy.VOUTH analog/dummy_l.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[27\].dummy.VOUTH
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[27\].dummy.VOUTH
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[27\].dummy.VSH
+ analog/dummy_l.dummy\[27\].dummy.VOUTH analog/dummy_l.dummy\[27\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[27\].dummy.VSH
+ analog/dummy_l.dummy\[27\].dummy.VOUTL analog/dummy_l.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[27\].dummy.VOUTL
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[27\].dummy.VOUTL
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[27\].dummy.VSH
+ analog/dummy_l.dummy\[27\].dummy.VOUTL analog/dummy_l.dummy\[27\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.FL
+ analog/dummy_l.dummy\[27\].dummy.FL analog/dummy_l.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.FL
+ analog/dummy_l.dummy\[27\].dummy.FL analog/dummy_l.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.FL
+ analog/dummy_l.dummy\[27\].dummy.FL analog/dummy_l.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.FL
+ analog/dummy_l.dummy\[27\].dummy.FL analog/dummy_l.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.FL
+ analog/dummy_l.dummy\[27\].dummy.FL analog/dummy_l.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.FL
+ analog/dummy_l.dummy\[27\].dummy.FL analog/dummy_l.dummy\[27\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[27\].dummy.VREF
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[27\].dummy.VSH
+ analog/dummy_l.dummy\[27\].dummy.VREF analog/dummy_l.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[27\].dummy.VSH
+ analog/dummy_l.dummy\[27\].dummy.VREF analog/dummy_l.dummy\[27\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[27\].dummy.VREF
+ analog/dummy_l.dummy\[27\].dummy.VSH analog/dummy_l.dummy\[27\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[2\].dummy.VSH
+ analog/dummy_l.dummy\[2\].dummy.VOUTH analog/dummy_l.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[2\].dummy.VOUTH
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[2\].dummy.VOUTH
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[2\].dummy.VSH
+ analog/dummy_l.dummy\[2\].dummy.VOUTH analog/dummy_l.dummy\[2\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[2\].dummy.VSH
+ analog/dummy_l.dummy\[2\].dummy.VOUTL analog/dummy_l.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[2\].dummy.VOUTL
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[2\].dummy.VOUTL
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[2\].dummy.VSH
+ analog/dummy_l.dummy\[2\].dummy.VOUTL analog/dummy_l.dummy\[2\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.FL
+ analog/dummy_l.dummy\[2\].dummy.FL analog/dummy_l.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.FL
+ analog/dummy_l.dummy\[2\].dummy.FL analog/dummy_l.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.FL
+ analog/dummy_l.dummy\[2\].dummy.FL analog/dummy_l.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.FL
+ analog/dummy_l.dummy\[2\].dummy.FL analog/dummy_l.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.FL
+ analog/dummy_l.dummy\[2\].dummy.FL analog/dummy_l.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.FL
+ analog/dummy_l.dummy\[2\].dummy.FL analog/dummy_l.dummy\[2\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[2\].dummy.VREF
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[2\].dummy.VSH
+ analog/dummy_l.dummy\[2\].dummy.VREF analog/dummy_l.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[2\].dummy.VSH
+ analog/dummy_l.dummy\[2\].dummy.VREF analog/dummy_l.dummy\[2\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[2\].dummy.VREF
+ analog/dummy_l.dummy\[2\].dummy.VSH analog/dummy_l.dummy\[2\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[3\].dummy.VSH
+ analog/dummy_l.dummy\[3\].dummy.VOUTH analog/dummy_l.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[3\].dummy.VOUTH
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[3\].dummy.VOUTH
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[3\].dummy.VSH
+ analog/dummy_l.dummy\[3\].dummy.VOUTH analog/dummy_l.dummy\[3\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[3\].dummy.VSH
+ analog/dummy_l.dummy\[3\].dummy.VOUTL analog/dummy_l.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[3\].dummy.VOUTL
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[3\].dummy.VOUTL
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[3\].dummy.VSH
+ analog/dummy_l.dummy\[3\].dummy.VOUTL analog/dummy_l.dummy\[3\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.FL
+ analog/dummy_l.dummy\[3\].dummy.FL analog/dummy_l.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.FL
+ analog/dummy_l.dummy\[3\].dummy.FL analog/dummy_l.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.FL
+ analog/dummy_l.dummy\[3\].dummy.FL analog/dummy_l.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.FL
+ analog/dummy_l.dummy\[3\].dummy.FL analog/dummy_l.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.FL
+ analog/dummy_l.dummy\[3\].dummy.FL analog/dummy_l.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.FL
+ analog/dummy_l.dummy\[3\].dummy.FL analog/dummy_l.dummy\[3\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[3\].dummy.VREF
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[3\].dummy.VSH
+ analog/dummy_l.dummy\[3\].dummy.VREF analog/dummy_l.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[3\].dummy.VSH
+ analog/dummy_l.dummy\[3\].dummy.VREF analog/dummy_l.dummy\[3\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[3\].dummy.VREF
+ analog/dummy_l.dummy\[3\].dummy.VSH analog/dummy_l.dummy\[3\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[4\].dummy.VSH
+ analog/dummy_l.dummy\[4\].dummy.VOUTH analog/dummy_l.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[4\].dummy.VOUTH
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[4\].dummy.VOUTH
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[4\].dummy.VSH
+ analog/dummy_l.dummy\[4\].dummy.VOUTH analog/dummy_l.dummy\[4\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[4\].dummy.VSH
+ analog/dummy_l.dummy\[4\].dummy.VOUTL analog/dummy_l.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[4\].dummy.VOUTL
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[4\].dummy.VOUTL
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[4\].dummy.VSH
+ analog/dummy_l.dummy\[4\].dummy.VOUTL analog/dummy_l.dummy\[4\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.FL
+ analog/dummy_l.dummy\[4\].dummy.FL analog/dummy_l.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.FL
+ analog/dummy_l.dummy\[4\].dummy.FL analog/dummy_l.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.FL
+ analog/dummy_l.dummy\[4\].dummy.FL analog/dummy_l.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.FL
+ analog/dummy_l.dummy\[4\].dummy.FL analog/dummy_l.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.FL
+ analog/dummy_l.dummy\[4\].dummy.FL analog/dummy_l.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.FL
+ analog/dummy_l.dummy\[4\].dummy.FL analog/dummy_l.dummy\[4\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[4\].dummy.VREF
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[4\].dummy.VSH
+ analog/dummy_l.dummy\[4\].dummy.VREF analog/dummy_l.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[4\].dummy.VSH
+ analog/dummy_l.dummy\[4\].dummy.VREF analog/dummy_l.dummy\[4\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[4\].dummy.VREF
+ analog/dummy_l.dummy\[4\].dummy.VSH analog/dummy_l.dummy\[4\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[5\].dummy.VSH
+ analog/dummy_l.dummy\[5\].dummy.VOUTH analog/dummy_l.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[5\].dummy.VOUTH
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[5\].dummy.VOUTH
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[5\].dummy.VSH
+ analog/dummy_l.dummy\[5\].dummy.VOUTH analog/dummy_l.dummy\[5\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[5\].dummy.VSH
+ analog/dummy_l.dummy\[5\].dummy.VOUTL analog/dummy_l.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[5\].dummy.VOUTL
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[5\].dummy.VOUTL
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[5\].dummy.VSH
+ analog/dummy_l.dummy\[5\].dummy.VOUTL analog/dummy_l.dummy\[5\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.FL
+ analog/dummy_l.dummy\[5\].dummy.FL analog/dummy_l.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.FL
+ analog/dummy_l.dummy\[5\].dummy.FL analog/dummy_l.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.FL
+ analog/dummy_l.dummy\[5\].dummy.FL analog/dummy_l.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.FL
+ analog/dummy_l.dummy\[5\].dummy.FL analog/dummy_l.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.FL
+ analog/dummy_l.dummy\[5\].dummy.FL analog/dummy_l.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.FL
+ analog/dummy_l.dummy\[5\].dummy.FL analog/dummy_l.dummy\[5\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[5\].dummy.VREF
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[5\].dummy.VSH
+ analog/dummy_l.dummy\[5\].dummy.VREF analog/dummy_l.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[5\].dummy.VSH
+ analog/dummy_l.dummy\[5\].dummy.VREF analog/dummy_l.dummy\[5\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[5\].dummy.VREF
+ analog/dummy_l.dummy\[5\].dummy.VSH analog/dummy_l.dummy\[5\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[6\].dummy.VSH
+ analog/dummy_l.dummy\[6\].dummy.VOUTH analog/dummy_l.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[6\].dummy.VOUTH
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[6\].dummy.VOUTH
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[6\].dummy.VSH
+ analog/dummy_l.dummy\[6\].dummy.VOUTH analog/dummy_l.dummy\[6\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[6\].dummy.VSH
+ analog/dummy_l.dummy\[6\].dummy.VOUTL analog/dummy_l.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[6\].dummy.VOUTL
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[6\].dummy.VOUTL
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[6\].dummy.VSH
+ analog/dummy_l.dummy\[6\].dummy.VOUTL analog/dummy_l.dummy\[6\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.FL
+ analog/dummy_l.dummy\[6\].dummy.FL analog/dummy_l.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.FL
+ analog/dummy_l.dummy\[6\].dummy.FL analog/dummy_l.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.FL
+ analog/dummy_l.dummy\[6\].dummy.FL analog/dummy_l.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.FL
+ analog/dummy_l.dummy\[6\].dummy.FL analog/dummy_l.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.FL
+ analog/dummy_l.dummy\[6\].dummy.FL analog/dummy_l.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.FL
+ analog/dummy_l.dummy\[6\].dummy.FL analog/dummy_l.dummy\[6\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[6\].dummy.VREF
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[6\].dummy.VSH
+ analog/dummy_l.dummy\[6\].dummy.VREF analog/dummy_l.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[6\].dummy.VSH
+ analog/dummy_l.dummy\[6\].dummy.VREF analog/dummy_l.dummy\[6\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[6\].dummy.VREF
+ analog/dummy_l.dummy\[6\].dummy.VSH analog/dummy_l.dummy\[6\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[7\].dummy.VSH
+ analog/dummy_l.dummy\[7\].dummy.VOUTH analog/dummy_l.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[7\].dummy.VOUTH
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[7\].dummy.VOUTH
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[7\].dummy.VSH
+ analog/dummy_l.dummy\[7\].dummy.VOUTH analog/dummy_l.dummy\[7\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[7\].dummy.VSH
+ analog/dummy_l.dummy\[7\].dummy.VOUTL analog/dummy_l.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[7\].dummy.VOUTL
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[7\].dummy.VOUTL
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[7\].dummy.VSH
+ analog/dummy_l.dummy\[7\].dummy.VOUTL analog/dummy_l.dummy\[7\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.FL
+ analog/dummy_l.dummy\[7\].dummy.FL analog/dummy_l.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.FL
+ analog/dummy_l.dummy\[7\].dummy.FL analog/dummy_l.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.FL
+ analog/dummy_l.dummy\[7\].dummy.FL analog/dummy_l.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.FL
+ analog/dummy_l.dummy\[7\].dummy.FL analog/dummy_l.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.FL
+ analog/dummy_l.dummy\[7\].dummy.FL analog/dummy_l.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.FL
+ analog/dummy_l.dummy\[7\].dummy.FL analog/dummy_l.dummy\[7\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[7\].dummy.VREF
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[7\].dummy.VSH
+ analog/dummy_l.dummy\[7\].dummy.VREF analog/dummy_l.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[7\].dummy.VSH
+ analog/dummy_l.dummy\[7\].dummy.VREF analog/dummy_l.dummy\[7\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[7\].dummy.VREF
+ analog/dummy_l.dummy\[7\].dummy.VSH analog/dummy_l.dummy\[7\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[8\].dummy.VSH
+ analog/dummy_l.dummy\[8\].dummy.VOUTH analog/dummy_l.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[8\].dummy.VOUTH
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[8\].dummy.VOUTH
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[8\].dummy.VSH
+ analog/dummy_l.dummy\[8\].dummy.VOUTH analog/dummy_l.dummy\[8\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[8\].dummy.VSH
+ analog/dummy_l.dummy\[8\].dummy.VOUTL analog/dummy_l.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[8\].dummy.VOUTL
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[8\].dummy.VOUTL
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[8\].dummy.VSH
+ analog/dummy_l.dummy\[8\].dummy.VOUTL analog/dummy_l.dummy\[8\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.FL
+ analog/dummy_l.dummy\[8\].dummy.FL analog/dummy_l.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.FL
+ analog/dummy_l.dummy\[8\].dummy.FL analog/dummy_l.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.FL
+ analog/dummy_l.dummy\[8\].dummy.FL analog/dummy_l.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.FL
+ analog/dummy_l.dummy\[8\].dummy.FL analog/dummy_l.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.FL
+ analog/dummy_l.dummy\[8\].dummy.FL analog/dummy_l.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.FL
+ analog/dummy_l.dummy\[8\].dummy.FL analog/dummy_l.dummy\[8\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[8\].dummy.VREF
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[8\].dummy.VSH
+ analog/dummy_l.dummy\[8\].dummy.VREF analog/dummy_l.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[8\].dummy.VSH
+ analog/dummy_l.dummy\[8\].dummy.VREF analog/dummy_l.dummy\[8\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[8\].dummy.VREF
+ analog/dummy_l.dummy\[8\].dummy.VSH analog/dummy_l.dummy\[8\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[9\].dummy.VSH
+ analog/dummy_l.dummy\[9\].dummy.VOUTH analog/dummy_l.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[9\].dummy.VOUTH
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[9\].dummy.VOUTH
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[9\].dummy.VSH
+ analog/dummy_l.dummy\[9\].dummy.VOUTH analog/dummy_l.dummy\[9\].dummy.VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[9\].dummy.VSH
+ analog/dummy_l.dummy\[9\].dummy.VOUTL analog/dummy_l.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[9\].dummy.VOUTL
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[9\].dummy.VOUTL
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[9\].dummy.VSH
+ analog/dummy_l.dummy\[9\].dummy.VOUTL analog/dummy_l.dummy\[9\].dummy.VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap\[0\].cap/impl
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.FL
+ analog/dummy_l.dummy\[9\].dummy.FL analog/dummy_l.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap\[1\].cap/impl
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.FL
+ analog/dummy_l.dummy\[9\].dummy.FL analog/dummy_l.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap\[2\].cap/impl
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.FL
+ analog/dummy_l.dummy\[9\].dummy.FL analog/dummy_l.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap\[3\].cap/impl
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.FL
+ analog/dummy_l.dummy\[9\].dummy.FL analog/dummy_l.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap\[4\].cap/impl
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.FL
+ analog/dummy_l.dummy\[9\].dummy.FL analog/dummy_l.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap\[5\].cap/impl
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.FL
+ analog/dummy_l.dummy\[9\].dummy.FL analog/dummy_l.dummy\[9\].dummy.FL
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[9\].dummy.VREF
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRH analog/dummy_l.dummy\[9\].dummy.VSH
+ analog/dummy_l.dummy\[9\].dummy.VREF analog/dummy_l.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[9\].dummy.VSH
+ analog/dummy_l.dummy\[9\].dummy.VREF analog/dummy_l.dummy\[9\].dummy.VREF
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/dummy_l.dummy\[0\].dummy.CRHB analog/dummy_l.dummy\[9\].dummy.VREF
+ analog/dummy_l.dummy\[9\].dummy.VSH analog/dummy_l.dummy\[9\].dummy.VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/dummy_l.tieh.impl AVDD VSS analog/dummy_l.dummy\[0\].dummy.CRHB
+ sg13g2f_TIEH
Xanalog/dummy_l.tiel.impl AVDD VSS analog/dummy_l.dummy\[0\].dummy.CRH
+ sg13g2f_TIEL
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[0\] analog/LSB_H_VSH\[1\] analog/VOUTH analog/LSB_H_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[0\] analog/VOUTH analog/LSB_H_VSH\[1\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[0\] analog/VOUTH analog/LSB_H_VSH\[1\] analog/LSB_H_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[0\] analog/LSB_H_VSH\[1\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[0\] analog/LSB_H_VSH\[1\] analog/VOUTL analog/LSB_H_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[0\] analog/VOUTL analog/LSB_H_VSH\[1\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[0\] analog/VOUTL analog/LSB_H_VSH\[1\] analog/LSB_H_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[0\] analog/LSB_H_VSH\[1\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap\[0\].cap/impl
+ analog/LSB_H_VSH\[1\] analog/LSB_H_FL\[1\] analog/LSB_H_FL\[1\]
+ analog/LSB_H_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap\[1\].cap/impl
+ analog/LSB_H_VSH\[1\] analog/LSB_H_FL\[1\] analog/LSB_H_FL\[1\]
+ analog/LSB_H_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap\[2\].cap/impl
+ analog/LSB_H_VSH\[1\] analog/LSB_H_FL\[1\] analog/LSB_H_FL\[1\]
+ analog/LSB_H_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap\[3\].cap/impl
+ analog/LSB_H_VSH\[1\] analog/LSB_H_FL\[1\] analog/LSB_H_FL\[1\]
+ analog/LSB_H_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap\[4\].cap/impl
+ analog/LSB_H_VSH\[1\] analog/LSB_H_FL\[1\] analog/LSB_H_FL\[1\]
+ analog/LSB_H_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap\[5\].cap/impl
+ analog/LSB_H_VSH\[1\] analog/LSB_H_FL\[1\] analog/LSB_H_FL\[1\]
+ analog/LSB_H_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[1\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[1\] VREFH analog/LSB_H_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[1\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[1\] analog/LSB_H_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[1\] analog/LSB_H_VSH\[2\] analog/VOUTH analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[1\] analog/VOUTH analog/LSB_H_VSH\[2\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[1\] analog/VOUTH analog/LSB_H_VSH\[2\] analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[1\] analog/LSB_H_VSH\[2\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[1\] analog/LSB_H_VSH\[2\] analog/VOUTH analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[1\] analog/VOUTH analog/LSB_H_VSH\[2\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[1\] analog/VOUTH analog/LSB_H_VSH\[2\] analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[1\] analog/LSB_H_VSH\[2\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[1\] analog/LSB_H_VSH\[2\] analog/VOUTL analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[1\] analog/VOUTL analog/LSB_H_VSH\[2\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[1\] analog/VOUTL analog/LSB_H_VSH\[2\] analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[1\] analog/LSB_H_VSH\[2\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[1\] analog/LSB_H_VSH\[2\] analog/VOUTL analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[1\] analog/VOUTL analog/LSB_H_VSH\[2\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[1\] analog/VOUTL analog/LSB_H_VSH\[2\] analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[1\] analog/LSB_H_VSH\[2\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[0\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[10\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[11\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[1\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[2\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[3\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[4\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[5\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[6\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[7\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[8\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap\[9\].cap/impl
+ analog/LSB_H_VSH\[2\] analog/LSB_H_FL\[2\] analog/LSB_H_FL\[2\]
+ analog/LSB_H_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[2\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[2\] VREFH analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[2\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[2\] analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[2\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[2\] VREFH analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[2\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[2\] analog/LSB_H_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[2\] analog/LSB_H_VSH\[3\] analog/VOUTH analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[2\] analog/VOUTH analog/LSB_H_VSH\[3\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[2\] analog/VOUTH analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[2\] analog/LSB_H_VSH\[3\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[2\] analog/LSB_H_VSH\[3\] analog/VOUTH analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[2\] analog/VOUTH analog/LSB_H_VSH\[3\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[2\] analog/VOUTH analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[2\] analog/LSB_H_VSH\[3\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[2\] analog/LSB_H_VSH\[3\] analog/VOUTH analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[2\] analog/VOUTH analog/LSB_H_VSH\[3\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[2\] analog/VOUTH analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[2\] analog/LSB_H_VSH\[3\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[2\] analog/LSB_H_VSH\[3\] analog/VOUTH analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[2\] analog/VOUTH analog/LSB_H_VSH\[3\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[2\] analog/VOUTH analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[2\] analog/LSB_H_VSH\[3\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[2\] analog/LSB_H_VSH\[3\] analog/VOUTL analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[2\] analog/VOUTL analog/LSB_H_VSH\[3\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[2\] analog/VOUTL analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[2\] analog/LSB_H_VSH\[3\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[2\] analog/LSB_H_VSH\[3\] analog/VOUTL analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[2\] analog/VOUTL analog/LSB_H_VSH\[3\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[2\] analog/VOUTL analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[2\] analog/LSB_H_VSH\[3\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[2\] analog/LSB_H_VSH\[3\] analog/VOUTL analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[2\] analog/VOUTL analog/LSB_H_VSH\[3\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[2\] analog/VOUTL analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[2\] analog/LSB_H_VSH\[3\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[2\] analog/LSB_H_VSH\[3\] analog/VOUTL analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[2\] analog/VOUTL analog/LSB_H_VSH\[3\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[2\] analog/VOUTL analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[2\] analog/LSB_H_VSH\[3\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[0\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[10\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[11\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[12\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[13\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[14\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[15\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[16\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[17\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[18\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[19\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[1\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[20\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[21\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[22\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[23\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[2\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[3\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[4\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[5\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[6\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[7\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[8\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap\[9\].cap/impl
+ analog/LSB_H_VSH\[3\] analog/LSB_H_FL\[3\] analog/LSB_H_FL\[3\]
+ analog/LSB_H_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[3\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[3\] VREFH analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[3\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[3\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[3\] VREFH analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[3\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[3\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[3\] VREFH analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[3\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[3\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[3\] VREFH analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[3\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[3\] analog/LSB_H_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTL analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_H_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[0\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[10\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[11\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[12\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[13\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[14\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[15\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[16\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[17\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[18\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[19\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[1\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[20\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[21\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[22\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[23\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[24\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[25\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[26\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[27\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[28\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[29\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[2\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[30\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[31\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[32\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[33\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[34\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[35\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[36\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[37\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[38\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[39\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[3\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[40\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[41\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[42\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[43\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[44\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[45\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[46\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[47\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[4\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[5\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[6\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[7\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[8\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap\[9\].cap/impl
+ analog/LSB_H_VSH\[4\] analog/LSB_H_FL\[4\] analog/LSB_H_FL\[4\]
+ analog/LSB_H_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[4\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[4\] VREFH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[4\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[4\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[4\] VREFH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[4\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[4\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[4\] VREFH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[4\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[4\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[4\] VREFH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[4\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[4\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[4\] VREFH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[4\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[4\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[4\] VREFH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[4\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[4\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[4\] VREFH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[4\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[4\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[4\] VREFH analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[4\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[4\] analog/LSB_H_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/lsb_cdac_h.cdac_unit.CRH analog/LSB_H_VSH\[0\] analog/VOUTH
+ analog/LSB_H_VSH\[0\] AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/lsb_cdac_h.cdac_unit.CRH analog/VOUTH analog/LSB_H_VSH\[0\]
+ analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/lsb_cdac_h.cdac_unit.CRHB analog/VOUTH analog/LSB_H_VSH\[0\]
+ analog/LSB_H_VSH\[0\] AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/lsb_cdac_h.cdac_unit.CRHB analog/LSB_H_VSH\[0\] analog/VOUTH
+ analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/lsb_cdac_h.cdac_unit.CRH analog/LSB_H_VSH\[0\] analog/VOUTL
+ analog/LSB_H_VSH\[0\] AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/lsb_cdac_h.cdac_unit.CRH analog/VOUTL analog/LSB_H_VSH\[0\]
+ analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/lsb_cdac_h.cdac_unit.CRHB analog/VOUTL analog/LSB_H_VSH\[0\]
+ analog/LSB_H_VSH\[0\] AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/lsb_cdac_h.cdac_unit.CRHB analog/LSB_H_VSH\[0\] analog/VOUTL
+ analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.cap\[0\].cap/impl analog/LSB_H_VSH\[0\]
+ analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_unit.cap\[1\].cap/impl analog/LSB_H_VSH\[0\]
+ analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_unit.cap\[2\].cap/impl analog/LSB_H_VSH\[0\]
+ analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_unit.cap\[3\].cap/impl analog/LSB_H_VSH\[0\]
+ analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_unit.cap\[4\].cap/impl analog/LSB_H_VSH\[0\]
+ analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_unit.cap\[5\].cap/impl analog/LSB_H_VSH\[0\]
+ analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\] analog/LSB_H_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFH analog/LSB_H_VSH\[0\] VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_H_VSH\[0\] VREFH analog/LSB_H_VSH\[0\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_H_VSH\[0\] VREFH VREFH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFH analog/LSB_H_VSH\[0\] analog/LSB_H_VSH\[0\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_h.tieh.impl AVDD VSS analog/lsb_cdac_h.cdac_unit.CRHB
+ sg13g2f_TIEH
Xanalog/lsb_cdac_h.tiel.impl AVDD VSS analog/lsb_cdac_h.cdac_unit.CRH
+ sg13g2f_TIEL
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[0\] analog/LSB_L_VSH\[1\] analog/VOUTL analog/LSB_L_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[0\] analog/VOUTL analog/LSB_L_VSH\[1\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[0\] analog/VOUTL analog/LSB_L_VSH\[1\] analog/LSB_L_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[0\] analog/LSB_L_VSH\[1\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[0\] analog/LSB_L_VSH\[1\] analog/VOUTH analog/LSB_L_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[0\] analog/VOUTH analog/LSB_L_VSH\[1\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[0\] analog/VOUTH analog/LSB_L_VSH\[1\] analog/LSB_L_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[0\] analog/LSB_L_VSH\[1\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap\[0\].cap/impl
+ analog/LSB_L_VSH\[1\] analog/LSB_L_FL\[1\] analog/LSB_L_FL\[1\]
+ analog/LSB_L_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap\[1\].cap/impl
+ analog/LSB_L_VSH\[1\] analog/LSB_L_FL\[1\] analog/LSB_L_FL\[1\]
+ analog/LSB_L_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap\[2\].cap/impl
+ analog/LSB_L_VSH\[1\] analog/LSB_L_FL\[1\] analog/LSB_L_FL\[1\]
+ analog/LSB_L_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap\[3\].cap/impl
+ analog/LSB_L_VSH\[1\] analog/LSB_L_FL\[1\] analog/LSB_L_FL\[1\]
+ analog/LSB_L_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap\[4\].cap/impl
+ analog/LSB_L_VSH\[1\] analog/LSB_L_FL\[1\] analog/LSB_L_FL\[1\]
+ analog/LSB_L_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap\[5\].cap/impl
+ analog/LSB_L_VSH\[1\] analog/LSB_L_FL\[1\] analog/LSB_L_FL\[1\]
+ analog/LSB_L_FL\[1\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[1\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[1\] VREFL analog/LSB_L_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[1\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[1\] analog/LSB_L_VSH\[1\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[1\] analog/LSB_L_VSH\[2\] analog/VOUTL analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[1\] analog/VOUTL analog/LSB_L_VSH\[2\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[1\] analog/VOUTL analog/LSB_L_VSH\[2\] analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[1\] analog/LSB_L_VSH\[2\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[1\] analog/LSB_L_VSH\[2\] analog/VOUTL analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[1\] analog/VOUTL analog/LSB_L_VSH\[2\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[1\] analog/VOUTL analog/LSB_L_VSH\[2\] analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[1\] analog/LSB_L_VSH\[2\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[1\] analog/LSB_L_VSH\[2\] analog/VOUTH analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[1\] analog/VOUTH analog/LSB_L_VSH\[2\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[1\] analog/VOUTH analog/LSB_L_VSH\[2\] analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[1\] analog/LSB_L_VSH\[2\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[1\] analog/LSB_L_VSH\[2\] analog/VOUTH analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[1\] analog/VOUTH analog/LSB_L_VSH\[2\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[1\] analog/VOUTH analog/LSB_L_VSH\[2\] analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[1\] analog/LSB_L_VSH\[2\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[0\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[10\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[11\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[1\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[2\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[3\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[4\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[5\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[6\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[7\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[8\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap\[9\].cap/impl
+ analog/LSB_L_VSH\[2\] analog/LSB_L_FL\[2\] analog/LSB_L_FL\[2\]
+ analog/LSB_L_FL\[2\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[2\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[2\] VREFL analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[2\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[2\] analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[2\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[2\] VREFL analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[2\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[2\] analog/LSB_L_VSH\[2\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[2\] analog/LSB_L_VSH\[3\] analog/VOUTL analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[2\] analog/VOUTL analog/LSB_L_VSH\[3\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[2\] analog/VOUTL analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[2\] analog/LSB_L_VSH\[3\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[2\] analog/LSB_L_VSH\[3\] analog/VOUTL analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[2\] analog/VOUTL analog/LSB_L_VSH\[3\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[2\] analog/VOUTL analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[2\] analog/LSB_L_VSH\[3\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[2\] analog/LSB_L_VSH\[3\] analog/VOUTL analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[2\] analog/VOUTL analog/LSB_L_VSH\[3\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[2\] analog/VOUTL analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[2\] analog/LSB_L_VSH\[3\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[2\] analog/LSB_L_VSH\[3\] analog/VOUTL analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[2\] analog/VOUTL analog/LSB_L_VSH\[3\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[2\] analog/VOUTL analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[2\] analog/LSB_L_VSH\[3\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[2\] analog/LSB_L_VSH\[3\] analog/VOUTH analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[2\] analog/VOUTH analog/LSB_L_VSH\[3\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[2\] analog/VOUTH analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[2\] analog/LSB_L_VSH\[3\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[2\] analog/LSB_L_VSH\[3\] analog/VOUTH analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[2\] analog/VOUTH analog/LSB_L_VSH\[3\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[2\] analog/VOUTH analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[2\] analog/LSB_L_VSH\[3\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[2\] analog/LSB_L_VSH\[3\] analog/VOUTH analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[2\] analog/VOUTH analog/LSB_L_VSH\[3\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[2\] analog/VOUTH analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[2\] analog/LSB_L_VSH\[3\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[2\] analog/LSB_L_VSH\[3\] analog/VOUTH analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[2\] analog/VOUTH analog/LSB_L_VSH\[3\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[2\] analog/VOUTH analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[2\] analog/LSB_L_VSH\[3\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[0\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[10\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[11\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[12\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[13\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[14\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[15\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[16\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[17\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[18\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[19\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[1\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[20\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[21\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[22\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[23\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[2\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[3\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[4\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[5\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[6\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[7\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[8\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap\[9\].cap/impl
+ analog/LSB_L_VSH\[3\] analog/LSB_L_FL\[3\] analog/LSB_L_FL\[3\]
+ analog/LSB_L_FL\[3\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[3\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[3\] VREFL analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[3\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[3\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[3\] VREFL analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[3\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[3\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[3\] VREFL analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[3\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[3\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[3\] VREFL analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[3\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[3\] analog/LSB_L_VSH\[3\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1
+ analog/CRH\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2
+ analog/CRH\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1
+ analog/CRHB\[3\] analog/VOUTL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2
+ analog/CRHB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTL analog/VOUTL
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1
+ analog/CRL\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz2
+ analog/CRL\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1
+ analog/CRLB\[3\] analog/VOUTH analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2
+ analog/CRLB\[3\] analog/LSB_L_VSH\[4\] analog/VOUTH analog/VOUTH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[0\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[10\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[11\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[12\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[13\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[14\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[15\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[16\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[17\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[18\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[19\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[1\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[20\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[21\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[22\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[23\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[24\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[25\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[26\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[27\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[28\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[29\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[2\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[30\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[31\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[32\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[33\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[34\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[35\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[36\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[37\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[38\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[39\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[3\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[40\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[41\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[42\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[43\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[44\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[45\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[46\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[47\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[4\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[5\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[6\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[7\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[8\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap\[9\].cap/impl
+ analog/LSB_L_VSH\[4\] analog/LSB_L_FL\[4\] analog/LSB_L_FL\[4\]
+ analog/LSB_L_FL\[4\] AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[4\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[4\] VREFL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[4\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[4\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[4\] VREFL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[4\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[4\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[4\] VREFL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[4\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[4\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[4\] VREFL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[4\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[4\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[4\] VREFL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[4\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[4\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[4\] VREFL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[4\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[4\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[4\] VREFL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[4\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[4\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[4\] VREFL analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[4\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[4\] analog/LSB_L_VSH\[4\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/lsb_cdac_l.cdac_unit.CRH analog/LSB_L_VSH\[0\] analog/VOUTL
+ analog/LSB_L_VSH\[0\] AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/lsb_cdac_l.cdac_unit.CRH analog/VOUTL analog/LSB_L_VSH\[0\]
+ analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/lsb_cdac_l.cdac_unit.CRHB analog/VOUTL analog/LSB_L_VSH\[0\]
+ analog/LSB_L_VSH\[0\] AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/lsb_cdac_l.cdac_unit.CRHB analog/LSB_L_VSH\[0\] analog/VOUTL
+ analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/lsb_cdac_l.cdac_unit.CRH analog/LSB_L_VSH\[0\] analog/VOUTH
+ analog/LSB_L_VSH\[0\] AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/lsb_cdac_l.cdac_unit.CRH analog/VOUTH analog/LSB_L_VSH\[0\]
+ analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/lsb_cdac_l.cdac_unit.CRHB analog/VOUTH analog/LSB_L_VSH\[0\]
+ analog/LSB_L_VSH\[0\] AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/lsb_cdac_l.cdac_unit.CRHB analog/LSB_L_VSH\[0\] analog/VOUTH
+ analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.cap\[0\].cap/impl analog/LSB_L_VSH\[0\]
+ analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_unit.cap\[1\].cap/impl analog/LSB_L_VSH\[0\]
+ analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_unit.cap\[2\].cap/impl analog/LSB_L_VSH\[0\]
+ analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_unit.cap\[3\].cap/impl analog/LSB_L_VSH\[0\]
+ analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_unit.cap\[4\].cap/impl analog/LSB_L_VSH\[0\]
+ analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_unit.cap\[5\].cap/impl analog/LSB_L_VSH\[0\]
+ analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\] analog/LSB_L_FL\[0\]
+ AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CPRE VREFL analog/LSB_L_VSH\[0\] VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CPRE analog/LSB_L_VSH\[0\] VREFL analog/LSB_L_VSH\[0\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CPREB analog/LSB_L_VSH\[0\] VREFL VREFL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CPREB VREFL analog/LSB_L_VSH\[0\] analog/LSB_L_VSH\[0\]
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/lsb_cdac_l.tieh.impl AVDD VSS analog/lsb_cdac_l.cdac_unit.CRHB
+ sg13g2f_TIEH
Xanalog/lsb_cdac_l.tiel.impl AVDD VSS analog/lsb_cdac_l.cdac_unit.CRH
+ sg13g2f_TIEL
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_H_VSH VIP analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIP analog/MSB_H_VSH VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIP analog/MSB_H_VSH analog/MSB_H_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_H_VSH VIP VIP AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_h.cdac_unit.CRL analog/MSB_H_VSH VIN analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_h.cdac_unit.CRL VIN analog/MSB_H_VSH VIN AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_h.cdac_unit.CRLB VIN analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_h.cdac_unit.CRLB analog/MSB_H_VSH VIN VIN
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.cap\[0\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[10\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[11\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[12\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[13\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[14\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[15\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[16\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[17\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[18\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[19\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[1\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[20\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[21\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[22\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[23\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[24\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[25\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[26\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[27\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[28\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[29\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[2\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[30\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[31\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[32\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[33\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[34\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[35\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[36\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[37\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[38\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[39\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[3\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[40\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[41\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[42\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[43\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[44\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[45\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[46\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[47\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[48\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[49\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[4\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[50\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[51\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[52\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[53\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[54\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[55\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[56\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[57\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[58\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[59\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[5\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[60\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[61\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[62\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[63\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[64\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[65\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[66\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[67\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[68\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[69\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[6\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[70\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[71\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[72\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[73\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[74\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[75\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[76\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[77\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[78\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[79\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[7\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[80\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[81\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[82\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[83\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[84\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[85\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[86\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[87\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[88\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[89\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[8\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[90\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[91\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[92\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[93\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[94\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[95\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.cap\[9\].cap/impl analog/MSB_H_VSH
+ analog/MSB_H_FL analog/MSB_H_FL analog/MSB_H_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTH analog/MSB_H_VSH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_H_VSH analog/VOUTH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_H_VSH analog/VOUTH analog/VOUTH AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTH analog/MSB_H_VSH analog/MSB_H_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_h.tieh.impl AVDD VSS analog/msb_cdac_h.cdac_unit.CRLB
+ sg13g2f_TIEH
Xanalog/msb_cdac_h.tiel.impl AVDD VSS analog/msb_cdac_h.cdac_unit.CRL
+ sg13g2f_TIEL
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz1
+ analog/CPRE analog/MSB_L_VSH VIN analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2
+ analog/CPRE VIN analog/MSB_L_VSH VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz1
+ analog/CPREB VIN analog/MSB_L_VSH analog/MSB_L_VSH AVDD VSS
+ SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz2
+ analog/CPREB analog/MSB_L_VSH VIN VIN AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgn_lz1
+ analog/msb_cdac_l.cdac_unit.CRL analog/MSB_L_VSH VIP analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgn_lz2
+ analog/msb_cdac_l.cdac_unit.CRL VIP analog/MSB_L_VSH VIP AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz1
+ analog/msb_cdac_l.cdac_unit.CRLB VIP analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz2
+ analog/msb_cdac_l.cdac_unit.CRLB analog/MSB_L_VSH VIP VIP
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.cap\[0\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[10\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[11\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[12\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[13\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[14\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[15\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[16\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[17\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[18\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[19\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[1\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[20\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[21\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[22\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[23\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[24\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[25\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[26\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[27\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[28\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[29\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[2\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[30\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[31\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[32\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[33\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[34\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[35\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[36\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[37\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[38\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[39\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[3\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[40\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[41\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[42\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[43\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[44\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[45\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[46\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[47\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[48\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[49\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[4\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[50\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[51\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[52\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[53\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[54\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[55\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[56\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[57\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[58\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[59\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[5\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[60\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[61\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[62\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[63\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[64\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[65\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[66\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[67\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[68\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[69\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[6\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[70\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[71\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[72\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[73\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[74\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[75\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[76\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[77\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[78\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[79\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[7\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[80\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[81\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[82\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[83\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[84\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[85\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[86\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[87\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[88\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[89\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[8\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[90\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[91\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[92\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[93\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[94\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[95\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.cap\[9\].cap/impl analog/MSB_L_VSH
+ analog/MSB_L_FL analog/MSB_L_FL analog/MSB_L_FL AVDD VSS SARADC_CELL_INVX16_ASCAP
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz1
+ analog/CHOLD analog/VOUTL analog/MSB_L_VSH analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2
+ analog/CHOLD analog/MSB_L_VSH analog/VOUTL analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz1
+ analog/CHOLDB analog/MSB_L_VSH analog/VOUTL analog/VOUTL AVDD
+ VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz2
+ analog/CHOLDB analog/VOUTL analog/MSB_L_VSH analog/MSB_L_VSH
+ AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/msb_cdac_l.tieh.impl AVDD VSS analog/msb_cdac_l.cdac_unit.CRLB
+ sg13g2f_TIEH
Xanalog/msb_cdac_l.tiel.impl AVDD VSS analog/msb_cdac_l.cdac_unit.CRL
+ sg13g2f_TIEL
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz1 analog/CPRE
+ analog/VOUTH analog/VOUTL analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz2 analog/CPRE
+ analog/VOUTL analog/VOUTH analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgp_lz1 analog/CPREB
+ analog/VOUTL analog/VOUTH analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgp_lz2 analog/CPREB
+ analog/VOUTH analog/VOUTL analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz1 analog/CPRE
+ analog/VOUTH analog/VOUTL analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz2 analog/CPRE
+ analog/VOUTL analog/VOUTH analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgp_lz1 analog/CPREB
+ analog/VOUTL analog/VOUTH analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgp_lz2 analog/CPREB
+ analog/VOUTH analog/VOUTL analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgn_lz1 analog/CPRE
+ analog/VOUTH analog/VOUTL analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgn_lz2 analog/CPRE
+ analog/VOUTL analog/VOUTH analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgp_lz1 analog/CPREB
+ analog/VOUTL analog/VOUTH analog/VOUTH AVDD VSS SARADC_CELL_INVX0_ASSW
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgp_lz2 analog/CPREB
+ analog/VOUTH analog/VOUTL analog/VOUTL AVDD VSS SARADC_CELL_INVX0_ASSW
Xdigital/ins_051_ digital/state\[1\] digital/ins_017_ VSS
+ VDD sg13g2f_INVD1
Xdigital/ins_052_ digital/state\[0\] digital/ins_018_ VSS
+ VDD sg13g2f_INVD1
Xdigital/ins_053_ digital/mask\[0\] digital/ins_019_ VSS VDD
+ sg13g2f_INVD1
Xdigital/ins_054_ digital/mask\[1\] digital/ins_020_ VSS VDD
+ sg13g2f_INVD1
Xdigital/ins_055_ digital/mask\[2\] digital/ins_021_ VSS VDD
+ sg13g2f_INVD1
Xdigital/ins_056_ digital/mask\[3\] digital/ins_022_ VSS VDD
+ sg13g2f_INVD1
Xdigital/ins_057_ digital/mask\[4\] digital/ins_023_ VSS VDD
+ sg13g2f_INVD1
Xdigital/ins_058_ RST digital/ins_024_ VSS VDD sg13g2f_INVD1
Xdigital/ins_059_ RESULT[0] digital/ins_025_ VSS VDD sg13g2f_INVD1
Xdigital/ins_060_ RESULT[1] digital/ins_026_ VSS VDD sg13g2f_INVD1
Xdigital/ins_061_ RESULT[2] digital/ins_027_ VSS VDD sg13g2f_INVD1
Xdigital/ins_062_ RESULT[3] digital/ins_028_ VSS VDD sg13g2f_INVD1
Xdigital/ins_063_ RESULT[4] digital/ins_029_ VSS VDD sg13g2f_INVD1
Xdigital/ins_064_ digital/state\[1\] digital/ins_018_ RST
+ VDD VSS digital/ins_030_ sg13g2f_AOI21D1
Xdigital/ins_065_ digital/state\[1\] digital/ins_018_ RST
+ VDD VSS digital/ins_031_ sg13g2f_AO21D1
Xdigital/ins_066_ RST CMPO VDD VSS digital/ins_032_ sg13g2f_NR2D1
Xdigital/ins_067_ digital/mask\[0\] digital/ins_032_ RESULTN\[0\]
+ VDD VSS digital/ins_033_ sg13g2f_AO21D1
Xdigital/ins_068_ digital/ins_031_ digital/ins_033_ VDD VSS
+ digital/ins_000_ sg13g2f_AN2D1
Xdigital/ins_069_ digital/mask\[1\] digital/ins_032_ RESULTN\[1\]
+ VDD VSS digital/ins_034_ sg13g2f_AO21D1
Xdigital/ins_070_ digital/ins_031_ digital/ins_034_ VDD VSS
+ digital/ins_001_ sg13g2f_AN2D1
Xdigital/ins_071_ digital/mask\[2\] digital/ins_032_ RESULTN\[2\]
+ VDD VSS digital/ins_035_ sg13g2f_AO21D1
Xdigital/ins_072_ digital/ins_031_ digital/ins_035_ VDD VSS
+ digital/ins_002_ sg13g2f_AN2D1
Xdigital/ins_073_ digital/mask\[3\] digital/ins_032_ RESULTN\[3\]
+ VDD VSS digital/ins_036_ sg13g2f_AO21D1
Xdigital/ins_074_ digital/ins_031_ digital/ins_036_ VDD VSS
+ digital/ins_003_ sg13g2f_AN2D1
Xdigital/ins_075_ digital/mask\[4\] digital/ins_032_ RESULTN\[4\]
+ VDD VSS digital/ins_037_ sg13g2f_AO21D1
Xdigital/ins_076_ digital/ins_031_ digital/ins_037_ VDD VSS
+ digital/ins_004_ sg13g2f_AN2D1
Xdigital/ins_077_ digital/state\[1\] digital/ins_018_ digital/ins_024_
+ VDD VSS digital/ins_038_ sg13g2f_ND3D1
Xdigital/ins_078_ digital/ins_017_ digital/state\[0\] VDD
+ VSS SAMPLE sg13g2f_AN2D1
Xdigital/ins_079_ digital/ins_017_ digital/state\[0\] digital/ins_024_
+ VDD VSS digital/ins_039_ sg13g2f_ND3D1
Xdigital/ins_080_ digital/state\[1\] digital/state\[0\] VDD
+ VSS digital/ins_040_ sg13g2f_XNR2D1
Xdigital/ins_081_ RST digital/ins_040_ VDD VSS digital/ins_011_
+ sg13g2f_NR2D1
Xdigital/ins_082_ RST digital/ins_040_ digital/mask\[0\] VDD
+ VSS digital/ins_041_ sg13g2f_OAI21D1
Xdigital/ins_083_ digital/ins_020_ digital/ins_038_ digital/ins_041_
+ VDD VSS digital/ins_005_ sg13g2f_OAI21D1
Xdigital/ins_084_ RST digital/ins_040_ digital/mask\[1\] VDD
+ VSS digital/ins_042_ sg13g2f_OAI21D1
Xdigital/ins_085_ digital/ins_021_ digital/ins_038_ digital/ins_042_
+ VDD VSS digital/ins_006_ sg13g2f_OAI21D1
Xdigital/ins_086_ RST digital/ins_040_ digital/mask\[2\] VDD
+ VSS digital/ins_043_ sg13g2f_OAI21D1
Xdigital/ins_087_ digital/ins_022_ digital/ins_038_ digital/ins_043_
+ VDD VSS digital/ins_007_ sg13g2f_OAI21D1
Xdigital/ins_088_ RST digital/ins_040_ digital/mask\[3\] VDD
+ VSS digital/ins_044_ sg13g2f_OAI21D1
Xdigital/ins_089_ digital/ins_023_ digital/ins_038_ digital/ins_044_
+ VDD VSS digital/ins_008_ sg13g2f_OAI21D1
Xdigital/ins_090_ digital/ins_023_ digital/ins_011_ digital/ins_039_
+ VDD VSS digital/ins_009_ sg13g2f_OAI21D1
Xdigital/ins_091_ digital/ins_024_ GO digital/ins_040_ VDD
+ VSS digital/ins_045_ sg13g2f_ND3D1
Xdigital/ins_092_ digital/ins_019_ digital/ins_038_ digital/ins_045_
+ VDD VSS digital/ins_010_ sg13g2f_OAI21D1
Xdigital/ins_093_ digital/mask\[0\] digital/ins_024_ CMPO
+ VDD VSS digital/ins_046_ sg13g2f_ND3D1
Xdigital/ins_094_ digital/ins_025_ digital/ins_046_ digital/ins_030_
+ VDD VSS digital/ins_012_ sg13g2f_AOI21D1
Xdigital/ins_095_ digital/mask\[1\] digital/ins_024_ CMPO
+ VDD VSS digital/ins_047_ sg13g2f_ND3D1
Xdigital/ins_096_ digital/ins_026_ digital/ins_047_ digital/ins_030_
+ VDD VSS digital/ins_013_ sg13g2f_AOI21D1
Xdigital/ins_097_ digital/mask\[2\] digital/ins_024_ CMPO
+ VDD VSS digital/ins_048_ sg13g2f_ND3D1
Xdigital/ins_098_ digital/ins_027_ digital/ins_048_ digital/ins_030_
+ VDD VSS digital/ins_014_ sg13g2f_AOI21D1
Xdigital/ins_099_ digital/mask\[3\] digital/ins_024_ CMPO
+ VDD VSS digital/ins_049_ sg13g2f_ND3D1
Xdigital/ins_100_ digital/ins_028_ digital/ins_049_ digital/ins_030_
+ VDD VSS digital/ins_015_ sg13g2f_AOI21D1
Xdigital/ins_101_ digital/mask\[4\] digital/ins_024_ CMPO
+ VDD VSS digital/ins_050_ sg13g2f_ND3D1
Xdigital/ins_102_ digital/ins_029_ digital/ins_050_ digital/ins_030_
+ VDD VSS digital/ins_016_ sg13g2f_AOI21D1
Xdigital/ins_103_ digital/state\[1\] digital/state\[0\] VDD
+ VSS VALID sg13g2f_AN2D1
Xdigital/ins_104_ clknet_leaf_2_CLK digital/ins_000_ RESULTN\[0\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_105_ clknet_leaf_2_CLK digital/ins_001_ RESULTN\[1\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_106_ clknet_leaf_2_CLK digital/ins_002_ RESULTN\[2\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_107_ clknet_leaf_0_CLK digital/ins_003_ RESULTN\[3\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_108_ clknet_leaf_2_CLK digital/ins_004_ RESULTN\[4\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_109_ clknet_leaf_1_CLK digital/ins_005_ digital/mask\[0\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_110_ clknet_leaf_1_CLK digital/ins_006_ digital/mask\[1\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_111_ clknet_leaf_0_CLK digital/ins_007_ digital/mask\[2\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_112_ clknet_1_1__leaf_CLK digital/ins_008_ digital/mask\[3\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_113_ clknet_leaf_3_CLK digital/ins_009_ digital/mask\[4\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_114_ clknet_leaf_0_CLK digital/ins_010_ digital/state\[0\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_115_ clknet_leaf_0_CLK digital/ins_011_ digital/state\[1\]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_116_ clknet_leaf_3_CLK digital/ins_012_ RESULT[0]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_117_ clknet_leaf_1_CLK digital/ins_013_ RESULT[1]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_118_ clknet_leaf_1_CLK digital/ins_014_ RESULT[2]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_119_ clknet_leaf_3_CLK digital/ins_015_ RESULT[3]
+ VDD VSS sg13g2f_DFQD1
Xdigital/ins_120_ clknet_leaf_3_CLK digital/ins_016_ RESULT[4]
+ VDD VSS sg13g2f_DFQD1
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[0\].cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_unit_0_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_unit_0_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_unit_0_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_unit_0_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_unit_0_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_unit_0_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[1\].cdac_unit_1_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_1_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_2_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[2\].cdac_unit_3_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_1_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_2_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_3_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_4_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_5_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_6_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_h.cdac_bit\[3\].cdac_unit_7_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_0_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_0_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_0_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_0_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_0_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_0_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_1_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_1_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_1_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_1_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_1_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_1_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_2_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_2_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_2_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_2_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_2_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_2_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_3_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_3_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_3_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_3_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_3_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_3_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_4_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_4_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_4_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_4_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_4_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_4_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_5_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_5_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_5_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_5_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_5_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_5_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_6_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_6_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_6_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_6_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_6_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_6_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_7_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_7_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_7_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_7_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_7_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_7_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_8_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_8_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_8_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_8_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_8_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_8_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_9_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_9_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_9_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_9_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_9_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_9_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_10_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_10_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_10_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_10_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_10_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_10_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_11_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_11_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_11_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_11_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_11_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_11_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_12_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_12_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_12_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_12_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_12_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_12_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_13_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_13_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_13_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_13_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_13_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_13_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_14_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_14_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_14_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_14_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_14_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_14_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_15_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_15_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_15_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_15_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_h.cdac_unit_15_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_h.cdac_unit_15_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[0\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[1\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[2\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[3\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[4\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[5\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[6\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[7\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[8\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[9\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[10\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[11\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[12\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[13\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[14\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[15\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[16\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[17\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[18\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[19\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[20\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[21\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[22\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[23\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[24\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[25\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[26\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_h.dummy\[27\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgp_lz1_FILLM_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgp_lz1_FILLM_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz1_FILLM_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz1_FILLM_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgp_lz2_FILLM_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgp_lz2_FILLM_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz2_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz2_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz2_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz2_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz2_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz2_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz2_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[0\].impl/pgn_lz2_FILLA_7_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgp_lz1_FILLM_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgp_lz1_FILLM_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz1_FILLM_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz1_FILLM_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgp_lz2_FILLM_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgp_lz2_FILLM_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz2_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz2_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz2_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz2_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz2_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz2_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz2_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[1\].impl/pgn_lz2_FILLA_7_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgp_lz1_FILLM_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgp_lz1_FILLM_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgn_lz1_FILLM_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgn_lz1_FILLM_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgp_lz2_FILLM_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl.impl\[2\].impl/pgp_lz2_FILLM_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/sw_vouth2voutl_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLB_7_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPFILLA_7_0 SARADC_FILL1_NOPOWER
Xanalog/sw_vouth2voutl_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/sw_vouth2voutl_SW_TAPBB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/sw_vouth2voutl_SW_TAPAA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[0\].cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_unit_0_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_unit_0_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_unit_0_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_unit_0_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_unit_0_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_unit_0_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[1\].cdac_unit_1_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_1_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_2_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[2\].cdac_unit_3_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_1_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_2_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_3_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_4_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_5_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_6_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/lsb_cdac_l.cdac_bit\[3\].cdac_unit_7_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_0_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_0_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_0_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_0_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_0_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_0_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[1\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[1\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[1\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_1_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_1_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_1_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_1_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_1_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_1_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[2\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[2\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[2\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_2_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_2_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_2_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_2_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_2_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_2_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[3\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[3\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[3\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_3_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_3_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_3_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_3_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_3_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_3_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[4\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[4\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[4\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_4_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_4_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_4_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_4_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_4_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_4_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[5\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[5\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[5\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_5_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_5_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_5_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_5_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_5_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_5_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[6\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[6\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[6\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_6_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_6_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_6_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_6_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_6_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_6_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[7\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[7\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[7\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_7_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_7_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_7_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_7_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_7_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_7_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[8\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[8\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[8\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_8_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_8_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_8_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_8_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_8_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_8_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[9\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[9\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[9\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_9_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_9_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_9_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_9_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_9_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_9_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[10\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[10\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[10\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_10_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_10_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_10_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_10_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_10_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_10_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[11\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[11\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[11\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_11_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_11_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_11_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_11_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_11_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_11_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[12\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[12\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[12\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_12_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_12_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_12_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_12_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_12_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_12_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[13\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[13\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[13\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_13_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_13_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_13_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_13_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_13_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_13_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[14\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[14\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[14\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_14_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_14_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_14_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_14_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_14_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_14_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.vi2cap\[15\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2vouth\[15\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit.cap2voutl\[15\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_CAP_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_15_CAP_TAPB_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_15_CAP_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_CAP_TAPFILLB_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_CAP_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_CAP_TAPFILLA_0_1 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_CAP_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_15_CAP_TAPA_0_1 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_15_SW_TAPB_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/msb_cdac_l.cdac_unit_15_SW_TAPFILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_SW_TAPFILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/msb_cdac_l.cdac_unit_15_SW_TAPA_0_0 AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[0\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[1\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[2\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[3\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[4\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[5\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[6\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[7\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[8\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_SW_TAPB_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[9\].dummy.cdac_unit_0_SW_TAPA_0_0 AVDD
+ VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[10\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[11\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[12\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[13\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[14\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[15\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[16\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[17\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_CAP_TAPAA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[18\].dummy.cdac_unit_0_SW_TAPAA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[19\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[20\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[21\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[22\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[23\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[24\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[25\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[26\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.vi2cap\[0\].sw_vi2cap/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_2_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_3_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_4_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_5_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_6_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2vouth\[0\].sw_cap2vouth/pgn_lz2_FILLA_7_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgn_lz1_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit.cap2voutl\[0\].sw_cap2voutl/pgp_lz2_FILLM_1_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLB_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLB_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLB_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLB_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLB_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLB_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLB_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLA_0_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLA_1_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLA_2_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLA_3_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLA_4_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLA_5_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_FILLA_6_0 SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPFILLB_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPFILLA_0_1
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPA_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_SW_TAPB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_SW_TAPFILLB_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_SW_TAPFILLA_0_0
+ SARADC_FILL1_NOPOWER
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_SW_TAPA_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_CAP_TAPBB_0_1
+ AVDD VSS SARADC_FILLTIE2
Xanalog/dummy_l.dummy\[27\].dummy.cdac_unit_0_SW_TAPBB_0_0
+ AVDD VSS SARADC_FILLTIE2
Xtapcell_up_inst_1 AVDD VSS sg13g2f_TAPCELL
Xtapcell_dw_inst_1 AVDD VSS sg13g2f_TAPCELL
Xtapcell_up_inst_3 AVDD VSS sg13g2f_TAPCELL
Xtapcell_dw_inst_3 AVDD VSS sg13g2f_TAPCELL
Xtapcell_up_inst_7 AVDD VSS sg13g2f_TAPCELL
Xtapcell_dw_inst_7 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_25_ANALOG_2_Left_0 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_26_ANALOG_2_Left_1 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_27_ANALOG_2_Left_2 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_22_ANALOG_Left_3 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_23_ANALOG_Left_4 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_24_ANALOG_Left_5 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_25_ANALOG_2_Right_6 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_22_ANALOG_Right_7 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_23_ANALOG_Right_8 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_24_ANALOG_Right_9 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_26_ANALOG_2_Right_10 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_27_ANALOG_2_Right_11 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_28_ANALOG_Right_12 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_29_ANALOG_Right_13 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_30_ANALOG_Right_14 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_28_ANALOG_Left_15 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_29_ANALOG_Left_16 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_30_ANALOG_Left_17 AVDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_52_2_Right_18 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_51_2_Right_19 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_50_2_Right_20 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_49_2_Right_21 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_48_2_Right_22 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_47_2_Right_23 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_46_2_Right_24 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_45_2_Right_25 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_44_2_Right_26 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_43_2_Right_27 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_42_2_Right_28 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_41_2_Right_29 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_40_2_Right_30 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_39_2_Right_31 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_38_2_Right_32 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_37_2_Right_33 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_36_2_Right_34 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_35_2_Right_35 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_34_2_Right_36 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_33_2_Right_37 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_32_2_Right_38 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_31_2_Right_39 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_30_2_Right_40 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_29_2_Right_41 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_28_2_Right_42 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_27_2_Right_43 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_26_2_Right_44 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_25_2_Right_45 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_24_2_Right_46 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_23_2_Right_47 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_22_2_Right_48 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_21_2_Right_49 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_20_2_Right_50 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_19_2_Right_51 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_18_2_Right_52 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_17_2_Right_53 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_16_2_Right_54 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_15_2_Right_55 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_14_2_Right_56 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_13_2_Right_57 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_12_2_Right_58 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_11_2_Right_59 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_10_2_Right_60 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_9_2_Right_61 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_8_2_Right_62 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_7_2_Right_63 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_6_2_Right_64 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_5_2_Right_65 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_4_2_Right_66 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_3_2_Right_67 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_2_2_Right_68 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_1_2_Right_69 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_0_2_Right_70 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_52_2_Left_71 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_51_2_Left_72 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_50_2_Left_73 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_49_2_Left_74 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_48_2_Left_75 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_47_2_Left_76 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_46_2_Left_77 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_45_2_Left_78 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_44_2_Left_79 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_43_2_Left_80 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_42_2_Left_81 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_41_2_Left_82 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_40_2_Left_83 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_39_2_Left_84 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_38_2_Left_85 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_37_2_Left_86 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_36_2_Left_87 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_35_2_Left_88 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_34_2_Left_89 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_33_2_Left_90 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_32_2_Left_91 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_31_2_Left_92 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_30_2_Left_93 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_29_2_Left_94 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_28_2_Left_95 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_27_2_Left_96 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_26_2_Left_97 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_25_2_Left_98 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_24_2_Left_99 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_23_2_Left_100 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_22_2_Left_101 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_21_2_Left_102 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_20_2_Left_103 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_19_2_Left_104 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_18_2_Left_105 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_17_2_Left_106 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_16_2_Left_107 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_15_2_Left_108 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_14_2_Left_109 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_13_2_Left_110 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_12_2_Left_111 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_11_2_Left_112 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_10_2_Left_113 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_9_2_Left_114 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_8_2_Left_115 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_7_2_Left_116 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_6_2_Left_117 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_5_2_Left_118 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_4_2_Left_119 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_3_2_Left_120 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_2_2_Left_121 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_1_2_Left_122 VDD VSS sg13g2f_TAPCELL
XPHY_EDGE_ROW_0_2_Left_123 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_25_ANALOG_2_124 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_25_ANALOG_2_125 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_25_ANALOG_2_126 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_25_ANALOG_2_127 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_128 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_129 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_130 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_131 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_132 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_133 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_134 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_135 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_136 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_137 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_ANALOG_138 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_23_ANALOG_139 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_23_ANALOG_140 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_23_ANALOG_141 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_23_ANALOG_142 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_23_ANALOG_143 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_144 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_145 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_146 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_147 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_148 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_149 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_150 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_151 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_152 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_153 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_ANALOG_154 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_26_ANALOG_2_155 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_26_ANALOG_2_156 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_26_ANALOG_2_157 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_26_ANALOG_2_158 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_27_ANALOG_2_159 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_27_ANALOG_2_160 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_27_ANALOG_2_161 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_162 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_163 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_164 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_165 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_166 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_167 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_168 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_169 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_170 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_171 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_ANALOG_172 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_29_ANALOG_173 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_29_ANALOG_174 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_29_ANALOG_175 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_29_ANALOG_176 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_29_ANALOG_177 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_178 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_179 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_180 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_181 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_182 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_183 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_184 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_185 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_186 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_187 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_ANALOG_188 AVDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_52_2_189 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_50_2_190 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_48_2_191 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_46_2_192 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_44_2_193 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_42_2_194 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_40_2_195 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_38_2_196 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_36_2_197 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_34_2_198 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_32_2_199 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_30_2_200 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_28_2_201 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_26_2_202 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_24_2_203 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_22_2_204 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_20_2_205 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_18_2_206 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_16_2_207 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_14_2_208 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_12_2_209 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_10_2_210 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_8_2_211 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_6_2_212 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_4_2_213 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_2_2_214 VDD VSS sg13g2f_TAPCELL
XTAP_TAPCELL_ROW_0_2_215 VDD VSS sg13g2f_TAPCELL
Xclkbuf_regs_0_CLK CLK VDD VSS CLK_regs sg13g2f_BUFFD1
Xclkbuf_leaf_0_CLK clknet_1_1__leaf_CLK VDD VSS clknet_leaf_0_CLK
+ sg13g2f_BUFFD1
Xclkbuf_leaf_1_CLK clknet_1_1__leaf_CLK VDD VSS clknet_leaf_1_CLK
+ sg13g2f_BUFFD1
Xclkbuf_leaf_2_CLK clknet_1_0__leaf_CLK VDD VSS clknet_leaf_2_CLK
+ sg13g2f_BUFFD1
Xclkbuf_leaf_3_CLK clknet_1_0__leaf_CLK VDD VSS clknet_leaf_3_CLK
+ sg13g2f_BUFFD1
Xclkbuf_0_CLK CLK VDD VSS clknet_0_CLK sg13g2f_BUFFD1
Xclkbuf_1_0__f_CLK clknet_0_CLK VDD VSS clknet_1_0__leaf_CLK
+ sg13g2f_BUFFD1
Xclkbuf_1_1__f_CLK clknet_0_CLK VDD VSS clknet_1_1__leaf_CLK
+ sg13g2f_BUFFD1
Xclkload0 clknet_1_0__leaf_CLK _unconnected_0 VSS VDD sg13g2f_INVD1
Xclkbuf_0_CLK_regs CLK_regs VDD VSS clknet_0_CLK_regs sg13g2f_BUFFD1
Xclkbuf_1_0__f_CLK_regs clknet_0_CLK_regs VDD VSS clknet_1_0__leaf_CLK_regs
+ sg13g2f_BUFFD1
XFILLER_0_1390 VDD VSS sg13g2f_FILL8
XFILLER_0_1398 VDD VSS sg13g2f_FILL8
XFILLER_0_1406 VDD VSS sg13g2f_FILL8
XFILLER_0_1414 VDD VSS sg13g2f_FILL8
XFILLER_0_1422 VDD VSS sg13g2f_FILL8
XFILLER_0_1430 VDD VSS sg13g2f_FILL8
XFILLER_0_1438 VDD VSS sg13g2f_FILL8
XFILLER_0_1446 VDD VSS sg13g2f_FILL8
XFILLER_0_1454 VDD VSS sg13g2f_FILL8
XFILLER_0_1462 VDD VSS sg13g2f_FILL8
XFILLER_0_1470 VDD VSS sg13g2f_FILL8
XFILLER_0_1478 VDD VSS sg13g2f_FILL8
XFILLER_0_1486 VDD VSS sg13g2f_FILL8
XFILLER_0_1494 VDD VSS sg13g2f_FILL1
XFILLER_0_1502 VDD VSS sg13g2f_FILL8
XFILLER_0_1510 VDD VSS sg13g2f_FILL8
XFILLER_0_1518 VDD VSS sg13g2f_FILL8
XFILLER_0_1526 VDD VSS sg13g2f_FILL8
XFILLER_0_1534 VDD VSS sg13g2f_FILL8
XFILLER_0_1542 VDD VSS sg13g2f_FILL8
XFILLER_0_1550 VDD VSS sg13g2f_FILL1
XFILLER_1_1390 VDD VSS sg13g2f_FILL8
XFILLER_1_1398 VDD VSS sg13g2f_FILL8
XFILLER_1_1406 VDD VSS sg13g2f_FILL8
XFILLER_1_1414 VDD VSS sg13g2f_FILL8
XFILLER_1_1422 VDD VSS sg13g2f_FILL8
XFILLER_1_1430 VDD VSS sg13g2f_FILL8
XFILLER_1_1438 VDD VSS sg13g2f_FILL8
XFILLER_1_1446 VDD VSS sg13g2f_FILL8
XFILLER_1_1454 VDD VSS sg13g2f_FILL8
XFILLER_1_1462 VDD VSS sg13g2f_FILL8
XFILLER_1_1470 VDD VSS sg13g2f_FILL8
XFILLER_1_1478 VDD VSS sg13g2f_FILL8
XFILLER_1_1486 VDD VSS sg13g2f_FILL8
XFILLER_1_1494 VDD VSS sg13g2f_FILL8
XFILLER_1_1502 VDD VSS sg13g2f_FILL8
XFILLER_1_1510 VDD VSS sg13g2f_FILL4
XFILLER_1_1514 VDD VSS sg13g2f_FILL1
XFILLER_1_1526 VDD VSS sg13g2f_FILL8
XFILLER_1_1534 VDD VSS sg13g2f_FILL8
XFILLER_1_1542 VDD VSS sg13g2f_FILL8
XFILLER_1_1550 VDD VSS sg13g2f_FILL1
XFILLER_2_1390 VDD VSS sg13g2f_FILL8
XFILLER_2_1398 VDD VSS sg13g2f_FILL8
XFILLER_2_1406 VDD VSS sg13g2f_FILL8
XFILLER_2_1414 VDD VSS sg13g2f_FILL8
XFILLER_2_1422 VDD VSS sg13g2f_FILL8
XFILLER_2_1430 VDD VSS sg13g2f_FILL8
XFILLER_2_1438 VDD VSS sg13g2f_FILL8
XFILLER_2_1446 VDD VSS sg13g2f_FILL8
XFILLER_2_1454 VDD VSS sg13g2f_FILL8
XFILLER_2_1462 VDD VSS sg13g2f_FILL8
XFILLER_2_1470 VDD VSS sg13g2f_FILL8
XFILLER_2_1478 VDD VSS sg13g2f_FILL8
XFILLER_2_1486 VDD VSS sg13g2f_FILL8
XFILLER_2_1494 VDD VSS sg13g2f_FILL4
XFILLER_2_1505 VDD VSS sg13g2f_FILL8
XFILLER_2_1513 VDD VSS sg13g2f_FILL8
XFILLER_2_1521 VDD VSS sg13g2f_FILL8
XFILLER_2_1529 VDD VSS sg13g2f_FILL8
XFILLER_2_1537 VDD VSS sg13g2f_FILL8
XFILLER_2_1545 VDD VSS sg13g2f_FILL4
XFILLER_2_1549 VDD VSS sg13g2f_FILL2
XFILLER_3_1390 VDD VSS sg13g2f_FILL8
XFILLER_3_1398 VDD VSS sg13g2f_FILL8
XFILLER_3_1406 VDD VSS sg13g2f_FILL8
XFILLER_3_1414 VDD VSS sg13g2f_FILL8
XFILLER_3_1422 VDD VSS sg13g2f_FILL8
XFILLER_3_1430 VDD VSS sg13g2f_FILL8
XFILLER_3_1438 VDD VSS sg13g2f_FILL8
XFILLER_3_1446 VDD VSS sg13g2f_FILL8
XFILLER_3_1454 VDD VSS sg13g2f_FILL8
XFILLER_3_1462 VDD VSS sg13g2f_FILL8
XFILLER_3_1470 VDD VSS sg13g2f_FILL8
XFILLER_3_1478 VDD VSS sg13g2f_FILL8
XFILLER_3_1486 VDD VSS sg13g2f_FILL8
XFILLER_3_1494 VDD VSS sg13g2f_FILL8
XFILLER_3_1502 VDD VSS sg13g2f_FILL2
XFILLER_3_1504 VDD VSS sg13g2f_FILL1
XFILLER_3_1537 VDD VSS sg13g2f_FILL8
XFILLER_3_1545 VDD VSS sg13g2f_FILL4
XFILLER_3_1549 VDD VSS sg13g2f_FILL2
XFILLER_4_1390 VDD VSS sg13g2f_FILL8
XFILLER_4_1398 VDD VSS sg13g2f_FILL8
XFILLER_4_1406 VDD VSS sg13g2f_FILL8
XFILLER_4_1414 VDD VSS sg13g2f_FILL8
XFILLER_4_1422 VDD VSS sg13g2f_FILL8
XFILLER_4_1430 VDD VSS sg13g2f_FILL8
XFILLER_4_1438 VDD VSS sg13g2f_FILL8
XFILLER_4_1446 VDD VSS sg13g2f_FILL8
XFILLER_4_1454 VDD VSS sg13g2f_FILL8
XFILLER_4_1462 VDD VSS sg13g2f_FILL8
XFILLER_4_1470 VDD VSS sg13g2f_FILL8
XFILLER_4_1478 VDD VSS sg13g2f_FILL8
XFILLER_4_1486 VDD VSS sg13g2f_FILL8
XFILLER_4_1494 VDD VSS sg13g2f_FILL4
XFILLER_4_1505 VDD VSS sg13g2f_FILL8
XFILLER_4_1513 VDD VSS sg13g2f_FILL2
XFILLER_4_1515 VDD VSS sg13g2f_FILL1
XFILLER_4_1527 VDD VSS sg13g2f_FILL8
XFILLER_4_1535 VDD VSS sg13g2f_FILL8
XFILLER_4_1543 VDD VSS sg13g2f_FILL8
XFILLER_5_1390 VDD VSS sg13g2f_FILL8
XFILLER_5_1398 VDD VSS sg13g2f_FILL8
XFILLER_5_1406 VDD VSS sg13g2f_FILL8
XFILLER_5_1414 VDD VSS sg13g2f_FILL8
XFILLER_5_1422 VDD VSS sg13g2f_FILL8
XFILLER_5_1430 VDD VSS sg13g2f_FILL8
XFILLER_5_1438 VDD VSS sg13g2f_FILL8
XFILLER_5_1446 VDD VSS sg13g2f_FILL8
XFILLER_5_1454 VDD VSS sg13g2f_FILL8
XFILLER_5_1462 VDD VSS sg13g2f_FILL8
XFILLER_5_1470 VDD VSS sg13g2f_FILL8
XFILLER_5_1478 VDD VSS sg13g2f_FILL8
XFILLER_5_1486 VDD VSS sg13g2f_FILL8
XFILLER_5_1494 VDD VSS sg13g2f_FILL4
XFILLER_5_1498 VDD VSS sg13g2f_FILL2
XFILLER_5_1500 VDD VSS sg13g2f_FILL1
XFILLER_5_1543 VDD VSS sg13g2f_FILL8
XFILLER_6_1390 VDD VSS sg13g2f_FILL8
XFILLER_6_1398 VDD VSS sg13g2f_FILL8
XFILLER_6_1406 VDD VSS sg13g2f_FILL8
XFILLER_6_1414 VDD VSS sg13g2f_FILL8
XFILLER_6_1422 VDD VSS sg13g2f_FILL8
XFILLER_6_1430 VDD VSS sg13g2f_FILL8
XFILLER_6_1438 VDD VSS sg13g2f_FILL8
XFILLER_6_1446 VDD VSS sg13g2f_FILL8
XFILLER_6_1454 VDD VSS sg13g2f_FILL8
XFILLER_6_1462 VDD VSS sg13g2f_FILL8
XFILLER_6_1470 VDD VSS sg13g2f_FILL8
XFILLER_6_1478 VDD VSS sg13g2f_FILL8
XFILLER_6_1486 VDD VSS sg13g2f_FILL8
XFILLER_6_1494 VDD VSS sg13g2f_FILL4
XFILLER_6_1547 VDD VSS sg13g2f_FILL4
XFILLER_7_1390 VDD VSS sg13g2f_FILL8
XFILLER_7_1398 VDD VSS sg13g2f_FILL8
XFILLER_7_1406 VDD VSS sg13g2f_FILL8
XFILLER_7_1414 VDD VSS sg13g2f_FILL8
XFILLER_7_1422 VDD VSS sg13g2f_FILL8
XFILLER_7_1430 VDD VSS sg13g2f_FILL8
XFILLER_7_1438 VDD VSS sg13g2f_FILL8
XFILLER_7_1446 VDD VSS sg13g2f_FILL8
XFILLER_7_1454 VDD VSS sg13g2f_FILL8
XFILLER_7_1462 VDD VSS sg13g2f_FILL8
XFILLER_7_1470 VDD VSS sg13g2f_FILL8
XFILLER_7_1478 VDD VSS sg13g2f_FILL8
XFILLER_7_1486 VDD VSS sg13g2f_FILL8
XFILLER_7_1494 VDD VSS sg13g2f_FILL8
XFILLER_7_1502 VDD VSS sg13g2f_FILL8
XFILLER_7_1510 VDD VSS sg13g2f_FILL8
XFILLER_7_1518 VDD VSS sg13g2f_FILL8
XFILLER_7_1526 VDD VSS sg13g2f_FILL8
XFILLER_7_1534 VDD VSS sg13g2f_FILL8
XFILLER_7_1542 VDD VSS sg13g2f_FILL8
XFILLER_7_1550 VDD VSS sg13g2f_FILL1
XFILLER_8_1390 VDD VSS sg13g2f_FILL8
XFILLER_8_1398 VDD VSS sg13g2f_FILL8
XFILLER_8_1406 VDD VSS sg13g2f_FILL8
XFILLER_8_1414 VDD VSS sg13g2f_FILL8
XFILLER_8_1422 VDD VSS sg13g2f_FILL8
XFILLER_8_1430 VDD VSS sg13g2f_FILL8
XFILLER_8_1438 VDD VSS sg13g2f_FILL8
XFILLER_8_1446 VDD VSS sg13g2f_FILL8
XFILLER_8_1454 VDD VSS sg13g2f_FILL8
XFILLER_8_1462 VDD VSS sg13g2f_FILL8
XFILLER_8_1470 VDD VSS sg13g2f_FILL8
XFILLER_8_1478 VDD VSS sg13g2f_FILL8
XFILLER_8_1486 VDD VSS sg13g2f_FILL8
XFILLER_8_1494 VDD VSS sg13g2f_FILL4
XFILLER_8_1547 VDD VSS sg13g2f_FILL4
XFILLER_9_1390 VDD VSS sg13g2f_FILL8
XFILLER_9_1398 VDD VSS sg13g2f_FILL8
XFILLER_9_1406 VDD VSS sg13g2f_FILL8
XFILLER_9_1414 VDD VSS sg13g2f_FILL8
XFILLER_9_1422 VDD VSS sg13g2f_FILL8
XFILLER_9_1430 VDD VSS sg13g2f_FILL8
XFILLER_9_1438 VDD VSS sg13g2f_FILL8
XFILLER_9_1446 VDD VSS sg13g2f_FILL8
XFILLER_9_1454 VDD VSS sg13g2f_FILL8
XFILLER_9_1462 VDD VSS sg13g2f_FILL8
XFILLER_9_1470 VDD VSS sg13g2f_FILL8
XFILLER_9_1478 VDD VSS sg13g2f_FILL8
XFILLER_9_1486 VDD VSS sg13g2f_FILL8
XFILLER_9_1494 VDD VSS sg13g2f_FILL8
XFILLER_9_1502 VDD VSS sg13g2f_FILL8
XFILLER_9_1510 VDD VSS sg13g2f_FILL8
XFILLER_9_1518 VDD VSS sg13g2f_FILL8
XFILLER_9_1526 VDD VSS sg13g2f_FILL8
XFILLER_9_1534 VDD VSS sg13g2f_FILL8
XFILLER_9_1542 VDD VSS sg13g2f_FILL8
XFILLER_9_1550 VDD VSS sg13g2f_FILL1
XFILLER_10_1390 VDD VSS sg13g2f_FILL8
XFILLER_10_1398 VDD VSS sg13g2f_FILL8
XFILLER_10_1406 VDD VSS sg13g2f_FILL8
XFILLER_10_1414 VDD VSS sg13g2f_FILL8
XFILLER_10_1422 VDD VSS sg13g2f_FILL8
XFILLER_10_1430 VDD VSS sg13g2f_FILL8
XFILLER_10_1438 VDD VSS sg13g2f_FILL8
XFILLER_10_1446 VDD VSS sg13g2f_FILL8
XFILLER_10_1454 VDD VSS sg13g2f_FILL8
XFILLER_10_1462 VDD VSS sg13g2f_FILL8
XFILLER_10_1470 VDD VSS sg13g2f_FILL8
XFILLER_10_1478 VDD VSS sg13g2f_FILL8
XFILLER_10_1486 VDD VSS sg13g2f_FILL8
XFILLER_10_1494 VDD VSS sg13g2f_FILL4
XFILLER_10_1538 VDD VSS sg13g2f_FILL8
XFILLER_10_1546 VDD VSS sg13g2f_FILL4
XFILLER_10_1550 VDD VSS sg13g2f_FILL1
XFILLER_11_1390 VDD VSS sg13g2f_FILL8
XFILLER_11_1398 VDD VSS sg13g2f_FILL8
XFILLER_11_1406 VDD VSS sg13g2f_FILL8
XFILLER_11_1414 VDD VSS sg13g2f_FILL8
XFILLER_11_1422 VDD VSS sg13g2f_FILL8
XFILLER_11_1430 VDD VSS sg13g2f_FILL8
XFILLER_11_1438 VDD VSS sg13g2f_FILL8
XFILLER_11_1446 VDD VSS sg13g2f_FILL8
XFILLER_11_1454 VDD VSS sg13g2f_FILL8
XFILLER_11_1462 VDD VSS sg13g2f_FILL8
XFILLER_11_1470 VDD VSS sg13g2f_FILL8
XFILLER_11_1478 VDD VSS sg13g2f_FILL4
XFILLER_11_1482 VDD VSS sg13g2f_FILL2
XFILLER_11_1484 VDD VSS sg13g2f_FILL1
XFILLER_11_1548 VDD VSS sg13g2f_FILL2
XFILLER_11_1550 VDD VSS sg13g2f_FILL1
XFILLER_12_1390 VDD VSS sg13g2f_FILL8
XFILLER_12_1398 VDD VSS sg13g2f_FILL8
XFILLER_12_1406 VDD VSS sg13g2f_FILL8
XFILLER_12_1414 VDD VSS sg13g2f_FILL8
XFILLER_12_1422 VDD VSS sg13g2f_FILL8
XFILLER_12_1430 VDD VSS sg13g2f_FILL8
XFILLER_12_1438 VDD VSS sg13g2f_FILL8
XFILLER_12_1446 VDD VSS sg13g2f_FILL8
XFILLER_12_1454 VDD VSS sg13g2f_FILL8
XFILLER_12_1462 VDD VSS sg13g2f_FILL8
XFILLER_12_1470 VDD VSS sg13g2f_FILL8
XFILLER_12_1478 VDD VSS sg13g2f_FILL8
XFILLER_12_1486 VDD VSS sg13g2f_FILL8
XFILLER_12_1494 VDD VSS sg13g2f_FILL4
XFILLER_12_1505 VDD VSS sg13g2f_FILL4
XFILLER_12_1536 VDD VSS sg13g2f_FILL2
XFILLER_12_1538 VDD VSS sg13g2f_FILL1
XFILLER_12_1547 VDD VSS sg13g2f_FILL4
XFILLER_13_1390 VDD VSS sg13g2f_FILL8
XFILLER_13_1398 VDD VSS sg13g2f_FILL8
XFILLER_13_1406 VDD VSS sg13g2f_FILL8
XFILLER_13_1414 VDD VSS sg13g2f_FILL8
XFILLER_13_1422 VDD VSS sg13g2f_FILL8
XFILLER_13_1430 VDD VSS sg13g2f_FILL8
XFILLER_13_1438 VDD VSS sg13g2f_FILL8
XFILLER_13_1446 VDD VSS sg13g2f_FILL8
XFILLER_13_1454 VDD VSS sg13g2f_FILL8
XFILLER_13_1462 VDD VSS sg13g2f_FILL8
XFILLER_13_1470 VDD VSS sg13g2f_FILL8
XFILLER_13_1478 VDD VSS sg13g2f_FILL8
XFILLER_13_1486 VDD VSS sg13g2f_FILL8
XFILLER_13_1494 VDD VSS sg13g2f_FILL4
XFILLER_13_1498 VDD VSS sg13g2f_FILL2
XFILLER_13_1542 VDD VSS sg13g2f_FILL8
XFILLER_13_1550 VDD VSS sg13g2f_FILL1
XFILLER_14_1390 VDD VSS sg13g2f_FILL8
XFILLER_14_1398 VDD VSS sg13g2f_FILL8
XFILLER_14_1406 VDD VSS sg13g2f_FILL8
XFILLER_14_1414 VDD VSS sg13g2f_FILL8
XFILLER_14_1422 VDD VSS sg13g2f_FILL8
XFILLER_14_1430 VDD VSS sg13g2f_FILL8
XFILLER_14_1438 VDD VSS sg13g2f_FILL8
XFILLER_14_1446 VDD VSS sg13g2f_FILL8
XFILLER_14_1454 VDD VSS sg13g2f_FILL8
XFILLER_14_1462 VDD VSS sg13g2f_FILL8
XFILLER_14_1470 VDD VSS sg13g2f_FILL8
XFILLER_14_1478 VDD VSS sg13g2f_FILL4
XFILLER_14_1482 VDD VSS sg13g2f_FILL2
XFILLER_14_1484 VDD VSS sg13g2f_FILL1
XFILLER_14_1547 VDD VSS sg13g2f_FILL4
XFILLER_15_1390 VDD VSS sg13g2f_FILL8
XFILLER_15_1398 VDD VSS sg13g2f_FILL8
XFILLER_15_1406 VDD VSS sg13g2f_FILL8
XFILLER_15_1414 VDD VSS sg13g2f_FILL8
XFILLER_15_1422 VDD VSS sg13g2f_FILL8
XFILLER_15_1430 VDD VSS sg13g2f_FILL8
XFILLER_15_1438 VDD VSS sg13g2f_FILL8
XFILLER_15_1446 VDD VSS sg13g2f_FILL8
XFILLER_15_1454 VDD VSS sg13g2f_FILL8
XFILLER_15_1462 VDD VSS sg13g2f_FILL8
XFILLER_15_1470 VDD VSS sg13g2f_FILL8
XFILLER_15_1478 VDD VSS sg13g2f_FILL8
XFILLER_15_1486 VDD VSS sg13g2f_FILL8
XFILLER_15_1494 VDD VSS sg13g2f_FILL8
XFILLER_15_1502 VDD VSS sg13g2f_FILL8
XFILLER_15_1510 VDD VSS sg13g2f_FILL4
XFILLER_15_1525 VDD VSS sg13g2f_FILL8
XFILLER_15_1533 VDD VSS sg13g2f_FILL8
XFILLER_15_1541 VDD VSS sg13g2f_FILL8
XFILLER_15_1549 VDD VSS sg13g2f_FILL2
XFILLER_16_1390 VDD VSS sg13g2f_FILL8
XFILLER_16_1398 VDD VSS sg13g2f_FILL8
XFILLER_16_1406 VDD VSS sg13g2f_FILL8
XFILLER_16_1414 VDD VSS sg13g2f_FILL8
XFILLER_16_1422 VDD VSS sg13g2f_FILL8
XFILLER_16_1430 VDD VSS sg13g2f_FILL8
XFILLER_16_1438 VDD VSS sg13g2f_FILL8
XFILLER_16_1446 VDD VSS sg13g2f_FILL8
XFILLER_16_1454 VDD VSS sg13g2f_FILL8
XFILLER_16_1462 VDD VSS sg13g2f_FILL8
XFILLER_16_1470 VDD VSS sg13g2f_FILL8
XFILLER_16_1478 VDD VSS sg13g2f_FILL8
XFILLER_16_1486 VDD VSS sg13g2f_FILL8
XFILLER_16_1494 VDD VSS sg13g2f_FILL4
XFILLER_16_1547 VDD VSS sg13g2f_FILL4
XFILLER_17_1390 VDD VSS sg13g2f_FILL8
XFILLER_17_1398 VDD VSS sg13g2f_FILL8
XFILLER_17_1406 VDD VSS sg13g2f_FILL8
XFILLER_17_1414 VDD VSS sg13g2f_FILL8
XFILLER_17_1422 VDD VSS sg13g2f_FILL8
XFILLER_17_1430 VDD VSS sg13g2f_FILL8
XFILLER_17_1438 VDD VSS sg13g2f_FILL8
XFILLER_17_1446 VDD VSS sg13g2f_FILL8
XFILLER_17_1454 VDD VSS sg13g2f_FILL8
XFILLER_17_1462 VDD VSS sg13g2f_FILL8
XFILLER_17_1470 VDD VSS sg13g2f_FILL8
XFILLER_17_1478 VDD VSS sg13g2f_FILL8
XFILLER_17_1486 VDD VSS sg13g2f_FILL8
XFILLER_17_1494 VDD VSS sg13g2f_FILL8
XFILLER_17_1502 VDD VSS sg13g2f_FILL8
XFILLER_17_1510 VDD VSS sg13g2f_FILL8
XFILLER_17_1518 VDD VSS sg13g2f_FILL8
XFILLER_17_1526 VDD VSS sg13g2f_FILL8
XFILLER_17_1534 VDD VSS sg13g2f_FILL8
XFILLER_17_1542 VDD VSS sg13g2f_FILL8
XFILLER_17_1550 VDD VSS sg13g2f_FILL1
XFILLER_18_1390 VDD VSS sg13g2f_FILL8
XFILLER_18_1398 VDD VSS sg13g2f_FILL8
XFILLER_18_1406 VDD VSS sg13g2f_FILL8
XFILLER_18_1414 VDD VSS sg13g2f_FILL8
XFILLER_18_1422 VDD VSS sg13g2f_FILL8
XFILLER_18_1430 VDD VSS sg13g2f_FILL8
XFILLER_18_1438 VDD VSS sg13g2f_FILL8
XFILLER_18_1446 VDD VSS sg13g2f_FILL8
XFILLER_18_1454 VDD VSS sg13g2f_FILL8
XFILLER_18_1462 VDD VSS sg13g2f_FILL8
XFILLER_18_1470 VDD VSS sg13g2f_FILL8
XFILLER_18_1478 VDD VSS sg13g2f_FILL8
XFILLER_18_1486 VDD VSS sg13g2f_FILL8
XFILLER_18_1494 VDD VSS sg13g2f_FILL4
XFILLER_18_1505 VDD VSS sg13g2f_FILL8
XFILLER_18_1513 VDD VSS sg13g2f_FILL8
XFILLER_18_1521 VDD VSS sg13g2f_FILL8
XFILLER_18_1529 VDD VSS sg13g2f_FILL8
XFILLER_18_1537 VDD VSS sg13g2f_FILL8
XFILLER_18_1545 VDD VSS sg13g2f_FILL4
XFILLER_18_1549 VDD VSS sg13g2f_FILL2
XFILLER_19_1390 VDD VSS sg13g2f_FILL8
XFILLER_19_1398 VDD VSS sg13g2f_FILL8
XFILLER_19_1406 VDD VSS sg13g2f_FILL8
XFILLER_19_1414 VDD VSS sg13g2f_FILL8
XFILLER_19_1422 VDD VSS sg13g2f_FILL8
XFILLER_19_1430 VDD VSS sg13g2f_FILL8
XFILLER_19_1438 VDD VSS sg13g2f_FILL8
XFILLER_19_1446 VDD VSS sg13g2f_FILL8
XFILLER_19_1454 VDD VSS sg13g2f_FILL8
XFILLER_19_1462 VDD VSS sg13g2f_FILL8
XFILLER_19_1470 VDD VSS sg13g2f_FILL8
XFILLER_19_1478 VDD VSS sg13g2f_FILL8
XFILLER_19_1486 VDD VSS sg13g2f_FILL8
XFILLER_19_1494 VDD VSS sg13g2f_FILL1
XFILLER_19_1530 VDD VSS sg13g2f_FILL8
XFILLER_19_1538 VDD VSS sg13g2f_FILL8
XFILLER_19_1546 VDD VSS sg13g2f_FILL4
XFILLER_19_1550 VDD VSS sg13g2f_FILL1
XFILLER_20_1390 VDD VSS sg13g2f_FILL8
XFILLER_20_1398 VDD VSS sg13g2f_FILL8
XFILLER_20_1406 VDD VSS sg13g2f_FILL8
XFILLER_20_1414 VDD VSS sg13g2f_FILL8
XFILLER_20_1422 VDD VSS sg13g2f_FILL8
XFILLER_20_1430 VDD VSS sg13g2f_FILL8
XFILLER_20_1438 VDD VSS sg13g2f_FILL8
XFILLER_20_1446 VDD VSS sg13g2f_FILL8
XFILLER_20_1454 VDD VSS sg13g2f_FILL8
XFILLER_20_1462 VDD VSS sg13g2f_FILL8
XFILLER_20_1470 VDD VSS sg13g2f_FILL8
XFILLER_20_1478 VDD VSS sg13g2f_FILL1
XFILLER_20_1505 VDD VSS sg13g2f_FILL2
XFILLER_20_1507 VDD VSS sg13g2f_FILL1
XFILLER_20_1538 VDD VSS sg13g2f_FILL8
XFILLER_20_1546 VDD VSS sg13g2f_FILL4
XFILLER_20_1550 VDD VSS sg13g2f_FILL1
XFILLER_21_1390 VDD VSS sg13g2f_FILL8
XFILLER_21_1398 VDD VSS sg13g2f_FILL8
XFILLER_21_1406 VDD VSS sg13g2f_FILL8
XFILLER_21_1414 VDD VSS sg13g2f_FILL8
XFILLER_21_1422 VDD VSS sg13g2f_FILL8
XFILLER_21_1430 VDD VSS sg13g2f_FILL8
XFILLER_21_1438 VDD VSS sg13g2f_FILL8
XFILLER_21_1446 VDD VSS sg13g2f_FILL8
XFILLER_21_1454 VDD VSS sg13g2f_FILL8
XFILLER_21_1462 VDD VSS sg13g2f_FILL8
XFILLER_21_1470 VDD VSS sg13g2f_FILL8
XFILLER_21_1478 VDD VSS sg13g2f_FILL8
XFILLER_21_1486 VDD VSS sg13g2f_FILL8
XFILLER_21_1494 VDD VSS sg13g2f_FILL8
XFILLER_21_1502 VDD VSS sg13g2f_FILL8
XFILLER_21_1510 VDD VSS sg13g2f_FILL8
XFILLER_21_1518 VDD VSS sg13g2f_FILL8
XFILLER_21_1526 VDD VSS sg13g2f_FILL8
XFILLER_21_1534 VDD VSS sg13g2f_FILL8
XFILLER_21_1542 VDD VSS sg13g2f_FILL8
XFILLER_21_1550 VDD VSS sg13g2f_FILL1
XFILLER_22_7 AVDD VSS sg13g2f_FILL4
XFILLER_22_11 AVDD VSS sg13g2f_FILL1
XFILLER_22_47 AVDD VSS sg13g2f_FILL1
XFILLER_22_119 AVDD VSS sg13g2f_FILL8
XFILLER_22_127 AVDD VSS sg13g2f_FILL8
XFILLER_22_135 AVDD VSS sg13g2f_FILL8
XFILLER_22_143 AVDD VSS sg13g2f_FILL8
XFILLER_22_151 AVDD VSS sg13g2f_FILL8
XFILLER_22_159 AVDD VSS sg13g2f_FILL8
XFILLER_22_167 AVDD VSS sg13g2f_FILL8
XFILLER_22_175 AVDD VSS sg13g2f_FILL8
XFILLER_22_183 AVDD VSS sg13g2f_FILL8
XFILLER_22_191 AVDD VSS sg13g2f_FILL8
XFILLER_22_199 AVDD VSS sg13g2f_FILL8
XFILLER_22_207 AVDD VSS sg13g2f_FILL8
XFILLER_22_215 AVDD VSS sg13g2f_FILL8
XFILLER_22_223 AVDD VSS sg13g2f_FILL1
XFILLER_22_231 AVDD VSS sg13g2f_FILL8
XFILLER_22_239 AVDD VSS sg13g2f_FILL8
XFILLER_22_247 AVDD VSS sg13g2f_FILL8
XFILLER_22_255 AVDD VSS sg13g2f_FILL8
XFILLER_22_263 AVDD VSS sg13g2f_FILL8
XFILLER_22_271 AVDD VSS sg13g2f_FILL8
XFILLER_22_279 AVDD VSS sg13g2f_FILL8
XFILLER_22_287 AVDD VSS sg13g2f_FILL8
XFILLER_22_295 AVDD VSS sg13g2f_FILL8
XFILLER_22_303 AVDD VSS sg13g2f_FILL8
XFILLER_22_311 AVDD VSS sg13g2f_FILL8
XFILLER_22_319 AVDD VSS sg13g2f_FILL8
XFILLER_22_327 AVDD VSS sg13g2f_FILL8
XFILLER_22_335 AVDD VSS sg13g2f_FILL1
XFILLER_22_343 AVDD VSS sg13g2f_FILL8
XFILLER_22_351 AVDD VSS sg13g2f_FILL8
XFILLER_22_359 AVDD VSS sg13g2f_FILL8
XFILLER_22_367 AVDD VSS sg13g2f_FILL8
XFILLER_22_375 AVDD VSS sg13g2f_FILL8
XFILLER_22_383 AVDD VSS sg13g2f_FILL1
XFILLER_22_455 AVDD VSS sg13g2f_FILL8
XFILLER_22_463 AVDD VSS sg13g2f_FILL8
XFILLER_22_471 AVDD VSS sg13g2f_FILL8
XFILLER_22_479 AVDD VSS sg13g2f_FILL8
XFILLER_22_487 AVDD VSS sg13g2f_FILL8
XFILLER_22_495 AVDD VSS sg13g2f_FILL8
XFILLER_22_503 AVDD VSS sg13g2f_FILL8
XFILLER_22_511 AVDD VSS sg13g2f_FILL8
XFILLER_22_519 AVDD VSS sg13g2f_FILL8
XFILLER_22_527 AVDD VSS sg13g2f_FILL8
XFILLER_22_535 AVDD VSS sg13g2f_FILL8
XFILLER_22_543 AVDD VSS sg13g2f_FILL8
XFILLER_22_551 AVDD VSS sg13g2f_FILL8
XFILLER_22_559 AVDD VSS sg13g2f_FILL1
XFILLER_22_567 AVDD VSS sg13g2f_FILL8
XFILLER_22_575 AVDD VSS sg13g2f_FILL8
XFILLER_22_583 AVDD VSS sg13g2f_FILL8
XFILLER_22_591 AVDD VSS sg13g2f_FILL8
XFILLER_22_599 AVDD VSS sg13g2f_FILL8
XFILLER_22_607 AVDD VSS sg13g2f_FILL8
XFILLER_22_615 AVDD VSS sg13g2f_FILL8
XFILLER_22_623 AVDD VSS sg13g2f_FILL8
XFILLER_22_631 AVDD VSS sg13g2f_FILL8
XFILLER_22_639 AVDD VSS sg13g2f_FILL8
XFILLER_22_647 AVDD VSS sg13g2f_FILL8
XFILLER_22_655 AVDD VSS sg13g2f_FILL8
XFILLER_22_663 AVDD VSS sg13g2f_FILL8
XFILLER_22_671 AVDD VSS sg13g2f_FILL1
XFILLER_22_679 AVDD VSS sg13g2f_FILL8
XFILLER_22_687 AVDD VSS sg13g2f_FILL8
XFILLER_22_695 AVDD VSS sg13g2f_FILL8
XFILLER_22_703 AVDD VSS sg13g2f_FILL8
XFILLER_22_711 AVDD VSS sg13g2f_FILL8
XFILLER_22_719 AVDD VSS sg13g2f_FILL8
XFILLER_22_727 AVDD VSS sg13g2f_FILL8
XFILLER_22_735 AVDD VSS sg13g2f_FILL8
XFILLER_22_743 AVDD VSS sg13g2f_FILL8
XFILLER_22_751 AVDD VSS sg13g2f_FILL8
XFILLER_22_759 AVDD VSS sg13g2f_FILL8
XFILLER_22_767 AVDD VSS sg13g2f_FILL8
XFILLER_22_775 AVDD VSS sg13g2f_FILL8
XFILLER_22_783 AVDD VSS sg13g2f_FILL1
XFILLER_22_791 AVDD VSS sg13g2f_FILL8
XFILLER_22_799 AVDD VSS sg13g2f_FILL8
XFILLER_22_807 AVDD VSS sg13g2f_FILL8
XFILLER_22_815 AVDD VSS sg13g2f_FILL8
XFILLER_22_823 AVDD VSS sg13g2f_FILL8
XFILLER_22_831 AVDD VSS sg13g2f_FILL8
XFILLER_22_839 AVDD VSS sg13g2f_FILL8
XFILLER_22_847 AVDD VSS sg13g2f_FILL8
XFILLER_22_855 AVDD VSS sg13g2f_FILL8
XFILLER_22_863 AVDD VSS sg13g2f_FILL8
XFILLER_22_871 AVDD VSS sg13g2f_FILL8
XFILLER_22_879 AVDD VSS sg13g2f_FILL8
XFILLER_22_887 AVDD VSS sg13g2f_FILL8
XFILLER_22_895 AVDD VSS sg13g2f_FILL1
XFILLER_22_903 AVDD VSS sg13g2f_FILL8
XFILLER_22_911 AVDD VSS sg13g2f_FILL8
XFILLER_22_919 AVDD VSS sg13g2f_FILL8
XFILLER_22_927 AVDD VSS sg13g2f_FILL8
XFILLER_22_935 AVDD VSS sg13g2f_FILL8
XFILLER_22_943 AVDD VSS sg13g2f_FILL8
XFILLER_22_951 AVDD VSS sg13g2f_FILL8
XFILLER_22_959 AVDD VSS sg13g2f_FILL8
XFILLER_22_967 AVDD VSS sg13g2f_FILL8
XFILLER_22_975 AVDD VSS sg13g2f_FILL8
XFILLER_22_983 AVDD VSS sg13g2f_FILL8
XFILLER_22_991 AVDD VSS sg13g2f_FILL8
XFILLER_22_999 AVDD VSS sg13g2f_FILL8
XFILLER_22_1007 AVDD VSS sg13g2f_FILL1
XFILLER_22_1015 AVDD VSS sg13g2f_FILL8
XFILLER_22_1023 AVDD VSS sg13g2f_FILL8
XFILLER_22_1031 AVDD VSS sg13g2f_FILL8
XFILLER_22_1039 AVDD VSS sg13g2f_FILL8
XFILLER_22_1047 AVDD VSS sg13g2f_FILL8
XFILLER_22_1055 AVDD VSS sg13g2f_FILL8
XFILLER_22_1063 AVDD VSS sg13g2f_FILL8
XFILLER_22_1071 AVDD VSS sg13g2f_FILL8
XFILLER_22_1079 AVDD VSS sg13g2f_FILL8
XFILLER_22_1087 AVDD VSS sg13g2f_FILL8
XFILLER_22_1095 AVDD VSS sg13g2f_FILL8
XFILLER_22_1103 AVDD VSS sg13g2f_FILL8
XFILLER_22_1111 AVDD VSS sg13g2f_FILL8
XFILLER_22_1119 AVDD VSS sg13g2f_FILL1
XFILLER_22_1127 AVDD VSS sg13g2f_FILL8
XFILLER_22_1135 AVDD VSS sg13g2f_FILL4
XFILLER_22_1139 AVDD VSS sg13g2f_FILL2
XFILLER_22_1152 AVDD VSS sg13g2f_FILL8
XFILLER_22_1160 AVDD VSS sg13g2f_FILL8
XFILLER_22_1168 AVDD VSS sg13g2f_FILL8
XFILLER_22_1176 AVDD VSS sg13g2f_FILL8
XFILLER_22_1184 AVDD VSS sg13g2f_FILL8
XFILLER_22_1192 AVDD VSS sg13g2f_FILL8
XFILLER_22_1200 AVDD VSS sg13g2f_FILL8
XFILLER_22_1208 AVDD VSS sg13g2f_FILL8
XFILLER_22_1216 AVDD VSS sg13g2f_FILL8
XFILLER_22_1224 AVDD VSS sg13g2f_FILL8
XFILLER_22_1239 AVDD VSS sg13g2f_FILL8
XFILLER_22_1247 AVDD VSS sg13g2f_FILL8
XFILLER_22_1255 AVDD VSS sg13g2f_FILL8
XFILLER_22_1263 AVDD VSS sg13g2f_FILL4
XFILLER_22_1267 AVDD VSS sg13g2f_FILL1
XFILLER_22_1390 VDD VSS sg13g2f_FILL8
XFILLER_22_1398 VDD VSS sg13g2f_FILL8
XFILLER_22_1406 VDD VSS sg13g2f_FILL8
XFILLER_22_1414 VDD VSS sg13g2f_FILL8
XFILLER_22_1422 VDD VSS sg13g2f_FILL8
XFILLER_22_1430 VDD VSS sg13g2f_FILL8
XFILLER_22_1438 VDD VSS sg13g2f_FILL8
XFILLER_22_1446 VDD VSS sg13g2f_FILL8
XFILLER_22_1454 VDD VSS sg13g2f_FILL8
XFILLER_22_1462 VDD VSS sg13g2f_FILL8
XFILLER_22_1470 VDD VSS sg13g2f_FILL8
XFILLER_22_1478 VDD VSS sg13g2f_FILL8
XFILLER_22_1486 VDD VSS sg13g2f_FILL8
XFILLER_22_1494 VDD VSS sg13g2f_FILL4
XFILLER_22_1547 VDD VSS sg13g2f_FILL4
XFILLER_23_7 AVDD VSS sg13g2f_FILL4
XFILLER_23_11 AVDD VSS sg13g2f_FILL1
XFILLER_23_58 AVDD VSS sg13g2f_FILL4
XFILLER_23_126 AVDD VSS sg13g2f_FILL8
XFILLER_23_134 AVDD VSS sg13g2f_FILL8
XFILLER_23_142 AVDD VSS sg13g2f_FILL8
XFILLER_23_150 AVDD VSS sg13g2f_FILL8
XFILLER_23_158 AVDD VSS sg13g2f_FILL8
XFILLER_23_166 AVDD VSS sg13g2f_FILL8
XFILLER_23_174 AVDD VSS sg13g2f_FILL8
XFILLER_23_182 AVDD VSS sg13g2f_FILL8
XFILLER_23_190 AVDD VSS sg13g2f_FILL8
XFILLER_23_198 AVDD VSS sg13g2f_FILL8
XFILLER_23_206 AVDD VSS sg13g2f_FILL8
XFILLER_23_214 AVDD VSS sg13g2f_FILL8
XFILLER_23_222 AVDD VSS sg13g2f_FILL8
XFILLER_23_230 AVDD VSS sg13g2f_FILL1
XFILLER_23_238 AVDD VSS sg13g2f_FILL8
XFILLER_23_246 AVDD VSS sg13g2f_FILL8
XFILLER_23_254 AVDD VSS sg13g2f_FILL8
XFILLER_23_262 AVDD VSS sg13g2f_FILL8
XFILLER_23_270 AVDD VSS sg13g2f_FILL8
XFILLER_23_278 AVDD VSS sg13g2f_FILL8
XFILLER_23_286 AVDD VSS sg13g2f_FILL8
XFILLER_23_294 AVDD VSS sg13g2f_FILL8
XFILLER_23_302 AVDD VSS sg13g2f_FILL8
XFILLER_23_310 AVDD VSS sg13g2f_FILL8
XFILLER_23_318 AVDD VSS sg13g2f_FILL8
XFILLER_23_326 AVDD VSS sg13g2f_FILL8
XFILLER_23_334 AVDD VSS sg13g2f_FILL8
XFILLER_23_342 AVDD VSS sg13g2f_FILL8
XFILLER_23_350 AVDD VSS sg13g2f_FILL8
XFILLER_23_358 AVDD VSS sg13g2f_FILL8
XFILLER_23_366 AVDD VSS sg13g2f_FILL8
XFILLER_23_374 AVDD VSS sg13g2f_FILL8
XFILLER_23_382 AVDD VSS sg13g2f_FILL8
XFILLER_23_390 AVDD VSS sg13g2f_FILL4
XFILLER_23_394 AVDD VSS sg13g2f_FILL1
XFILLER_23_459 AVDD VSS sg13g2f_FILL2
XFILLER_23_461 AVDD VSS sg13g2f_FILL1
XFILLER_23_469 AVDD VSS sg13g2f_FILL8
XFILLER_23_477 AVDD VSS sg13g2f_FILL8
XFILLER_23_485 AVDD VSS sg13g2f_FILL8
XFILLER_23_493 AVDD VSS sg13g2f_FILL8
XFILLER_23_501 AVDD VSS sg13g2f_FILL8
XFILLER_23_509 AVDD VSS sg13g2f_FILL8
XFILLER_23_517 AVDD VSS sg13g2f_FILL8
XFILLER_23_525 AVDD VSS sg13g2f_FILL8
XFILLER_23_533 AVDD VSS sg13g2f_FILL8
XFILLER_23_541 AVDD VSS sg13g2f_FILL8
XFILLER_23_549 AVDD VSS sg13g2f_FILL8
XFILLER_23_557 AVDD VSS sg13g2f_FILL1
XFILLER_23_622 AVDD VSS sg13g2f_FILL8
XFILLER_23_630 AVDD VSS sg13g2f_FILL8
XFILLER_23_638 AVDD VSS sg13g2f_FILL8
XFILLER_23_646 AVDD VSS sg13g2f_FILL8
XFILLER_23_654 AVDD VSS sg13g2f_FILL8
XFILLER_23_662 AVDD VSS sg13g2f_FILL8
XFILLER_23_670 AVDD VSS sg13g2f_FILL8
XFILLER_23_678 AVDD VSS sg13g2f_FILL8
XFILLER_23_686 AVDD VSS sg13g2f_FILL4
XFILLER_23_690 AVDD VSS sg13g2f_FILL2
XFILLER_23_692 AVDD VSS sg13g2f_FILL1
XFILLER_23_700 AVDD VSS sg13g2f_FILL8
XFILLER_23_708 AVDD VSS sg13g2f_FILL8
XFILLER_23_716 AVDD VSS sg13g2f_FILL8
XFILLER_23_724 AVDD VSS sg13g2f_FILL8
XFILLER_23_732 AVDD VSS sg13g2f_FILL8
XFILLER_23_740 AVDD VSS sg13g2f_FILL8
XFILLER_23_748 AVDD VSS sg13g2f_FILL8
XFILLER_23_756 AVDD VSS sg13g2f_FILL8
XFILLER_23_764 AVDD VSS sg13g2f_FILL8
XFILLER_23_772 AVDD VSS sg13g2f_FILL8
XFILLER_23_780 AVDD VSS sg13g2f_FILL8
XFILLER_23_788 AVDD VSS sg13g2f_FILL8
XFILLER_23_796 AVDD VSS sg13g2f_FILL8
XFILLER_23_804 AVDD VSS sg13g2f_FILL8
XFILLER_23_812 AVDD VSS sg13g2f_FILL8
XFILLER_23_820 AVDD VSS sg13g2f_FILL8
XFILLER_23_828 AVDD VSS sg13g2f_FILL8
XFILLER_23_836 AVDD VSS sg13g2f_FILL8
XFILLER_23_844 AVDD VSS sg13g2f_FILL8
XFILLER_23_868 AVDD VSS sg13g2f_FILL8
XFILLER_23_876 AVDD VSS sg13g2f_FILL4
XFILLER_23_905 AVDD VSS sg13g2f_FILL8
XFILLER_23_913 AVDD VSS sg13g2f_FILL8
XFILLER_23_921 AVDD VSS sg13g2f_FILL2
XFILLER_23_923 AVDD VSS sg13g2f_FILL1
XFILLER_23_931 AVDD VSS sg13g2f_FILL8
XFILLER_23_939 AVDD VSS sg13g2f_FILL8
XFILLER_23_947 AVDD VSS sg13g2f_FILL8
XFILLER_23_955 AVDD VSS sg13g2f_FILL8
XFILLER_23_963 AVDD VSS sg13g2f_FILL8
XFILLER_23_971 AVDD VSS sg13g2f_FILL8
XFILLER_23_979 AVDD VSS sg13g2f_FILL8
XFILLER_23_987 AVDD VSS sg13g2f_FILL8
XFILLER_23_995 AVDD VSS sg13g2f_FILL8
XFILLER_23_1003 AVDD VSS sg13g2f_FILL8
XFILLER_23_1011 AVDD VSS sg13g2f_FILL8
XFILLER_23_1019 AVDD VSS sg13g2f_FILL2
XFILLER_23_1021 AVDD VSS sg13g2f_FILL1
XFILLER_23_1038 AVDD VSS sg13g2f_FILL8
XFILLER_23_1110 AVDD VSS sg13g2f_FILL8
XFILLER_23_1118 AVDD VSS sg13g2f_FILL8
XFILLER_23_1126 AVDD VSS sg13g2f_FILL8
XFILLER_23_1150 AVDD VSS sg13g2f_FILL4
XFILLER_23_1154 AVDD VSS sg13g2f_FILL1
XFILLER_23_1162 AVDD VSS sg13g2f_FILL8
XFILLER_23_1170 AVDD VSS sg13g2f_FILL8
XFILLER_23_1178 AVDD VSS sg13g2f_FILL8
XFILLER_23_1186 AVDD VSS sg13g2f_FILL8
XFILLER_23_1194 AVDD VSS sg13g2f_FILL8
XFILLER_23_1202 AVDD VSS sg13g2f_FILL8
XFILLER_23_1210 AVDD VSS sg13g2f_FILL8
XFILLER_23_1218 AVDD VSS sg13g2f_FILL8
XFILLER_23_1226 AVDD VSS sg13g2f_FILL8
XFILLER_23_1234 AVDD VSS sg13g2f_FILL8
XFILLER_23_1242 AVDD VSS sg13g2f_FILL8
XFILLER_23_1250 AVDD VSS sg13g2f_FILL8
XFILLER_23_1258 AVDD VSS sg13g2f_FILL8
XFILLER_23_1266 AVDD VSS sg13g2f_FILL2
XFILLER_23_1390 VDD VSS sg13g2f_FILL8
XFILLER_23_1398 VDD VSS sg13g2f_FILL8
XFILLER_23_1406 VDD VSS sg13g2f_FILL8
XFILLER_23_1414 VDD VSS sg13g2f_FILL8
XFILLER_23_1422 VDD VSS sg13g2f_FILL8
XFILLER_23_1430 VDD VSS sg13g2f_FILL8
XFILLER_23_1438 VDD VSS sg13g2f_FILL8
XFILLER_23_1446 VDD VSS sg13g2f_FILL8
XFILLER_23_1454 VDD VSS sg13g2f_FILL8
XFILLER_23_1462 VDD VSS sg13g2f_FILL8
XFILLER_23_1470 VDD VSS sg13g2f_FILL8
XFILLER_23_1478 VDD VSS sg13g2f_FILL8
XFILLER_23_1486 VDD VSS sg13g2f_FILL8
XFILLER_23_1494 VDD VSS sg13g2f_FILL8
XFILLER_23_1502 VDD VSS sg13g2f_FILL1
XFILLER_23_1545 VDD VSS sg13g2f_FILL4
XFILLER_23_1549 VDD VSS sg13g2f_FILL2
XFILLER_24_7 AVDD VSS sg13g2f_FILL4
XFILLER_24_11 AVDD VSS sg13g2f_FILL1
XFILLER_24_119 AVDD VSS sg13g2f_FILL8
XFILLER_24_127 AVDD VSS sg13g2f_FILL8
XFILLER_24_135 AVDD VSS sg13g2f_FILL8
XFILLER_24_143 AVDD VSS sg13g2f_FILL8
XFILLER_24_151 AVDD VSS sg13g2f_FILL8
XFILLER_24_159 AVDD VSS sg13g2f_FILL8
XFILLER_24_167 AVDD VSS sg13g2f_FILL8
XFILLER_24_175 AVDD VSS sg13g2f_FILL8
XFILLER_24_183 AVDD VSS sg13g2f_FILL8
XFILLER_24_191 AVDD VSS sg13g2f_FILL8
XFILLER_24_199 AVDD VSS sg13g2f_FILL8
XFILLER_24_207 AVDD VSS sg13g2f_FILL8
XFILLER_24_215 AVDD VSS sg13g2f_FILL8
XFILLER_24_223 AVDD VSS sg13g2f_FILL1
XFILLER_24_247 AVDD VSS sg13g2f_FILL8
XFILLER_24_255 AVDD VSS sg13g2f_FILL8
XFILLER_24_263 AVDD VSS sg13g2f_FILL8
XFILLER_24_271 AVDD VSS sg13g2f_FILL8
XFILLER_24_279 AVDD VSS sg13g2f_FILL8
XFILLER_24_287 AVDD VSS sg13g2f_FILL8
XFILLER_24_295 AVDD VSS sg13g2f_FILL8
XFILLER_24_303 AVDD VSS sg13g2f_FILL8
XFILLER_24_311 AVDD VSS sg13g2f_FILL8
XFILLER_24_319 AVDD VSS sg13g2f_FILL8
XFILLER_24_327 AVDD VSS sg13g2f_FILL8
XFILLER_24_335 AVDD VSS sg13g2f_FILL1
XFILLER_24_343 AVDD VSS sg13g2f_FILL8
XFILLER_24_351 AVDD VSS sg13g2f_FILL1
XFILLER_24_374 AVDD VSS sg13g2f_FILL8
XFILLER_24_382 AVDD VSS sg13g2f_FILL2
XFILLER_24_455 AVDD VSS sg13g2f_FILL8
XFILLER_24_463 AVDD VSS sg13g2f_FILL8
XFILLER_24_471 AVDD VSS sg13g2f_FILL8
XFILLER_24_479 AVDD VSS sg13g2f_FILL8
XFILLER_24_487 AVDD VSS sg13g2f_FILL8
XFILLER_24_495 AVDD VSS sg13g2f_FILL8
XFILLER_24_503 AVDD VSS sg13g2f_FILL8
XFILLER_24_511 AVDD VSS sg13g2f_FILL8
XFILLER_24_519 AVDD VSS sg13g2f_FILL8
XFILLER_24_527 AVDD VSS sg13g2f_FILL8
XFILLER_24_535 AVDD VSS sg13g2f_FILL8
XFILLER_24_543 AVDD VSS sg13g2f_FILL8
XFILLER_24_551 AVDD VSS sg13g2f_FILL8
XFILLER_24_559 AVDD VSS sg13g2f_FILL1
XFILLER_24_567 AVDD VSS sg13g2f_FILL8
XFILLER_24_575 AVDD VSS sg13g2f_FILL8
XFILLER_24_583 AVDD VSS sg13g2f_FILL8
XFILLER_24_591 AVDD VSS sg13g2f_FILL8
XFILLER_24_599 AVDD VSS sg13g2f_FILL8
XFILLER_24_607 AVDD VSS sg13g2f_FILL8
XFILLER_24_615 AVDD VSS sg13g2f_FILL8
XFILLER_24_623 AVDD VSS sg13g2f_FILL8
XFILLER_24_631 AVDD VSS sg13g2f_FILL8
XFILLER_24_639 AVDD VSS sg13g2f_FILL8
XFILLER_24_647 AVDD VSS sg13g2f_FILL8
XFILLER_24_655 AVDD VSS sg13g2f_FILL8
XFILLER_24_663 AVDD VSS sg13g2f_FILL8
XFILLER_24_671 AVDD VSS sg13g2f_FILL1
XFILLER_24_679 AVDD VSS sg13g2f_FILL2
XFILLER_24_681 AVDD VSS sg13g2f_FILL1
XFILLER_24_746 AVDD VSS sg13g2f_FILL8
XFILLER_24_754 AVDD VSS sg13g2f_FILL8
XFILLER_24_762 AVDD VSS sg13g2f_FILL8
XFILLER_24_770 AVDD VSS sg13g2f_FILL8
XFILLER_24_778 AVDD VSS sg13g2f_FILL4
XFILLER_24_782 AVDD VSS sg13g2f_FILL2
XFILLER_24_855 AVDD VSS sg13g2f_FILL8
XFILLER_24_863 AVDD VSS sg13g2f_FILL8
XFILLER_24_871 AVDD VSS sg13g2f_FILL8
XFILLER_24_879 AVDD VSS sg13g2f_FILL1
XFILLER_24_928 AVDD VSS sg13g2f_FILL2
XFILLER_24_994 AVDD VSS sg13g2f_FILL8
XFILLER_24_1002 AVDD VSS sg13g2f_FILL4
XFILLER_24_1006 AVDD VSS sg13g2f_FILL2
XFILLER_24_1101 AVDD VSS sg13g2f_FILL4
XFILLER_24_1105 AVDD VSS sg13g2f_FILL2
XFILLER_24_1118 AVDD VSS sg13g2f_FILL2
XFILLER_24_1127 AVDD VSS sg13g2f_FILL1
XFILLER_24_1153 AVDD VSS sg13g2f_FILL4
XFILLER_24_1198 AVDD VSS sg13g2f_FILL8
XFILLER_24_1206 AVDD VSS sg13g2f_FILL8
XFILLER_24_1214 AVDD VSS sg13g2f_FILL8
XFILLER_24_1222 AVDD VSS sg13g2f_FILL8
XFILLER_24_1230 AVDD VSS sg13g2f_FILL2
XFILLER_24_1239 AVDD VSS sg13g2f_FILL8
XFILLER_24_1247 AVDD VSS sg13g2f_FILL8
XFILLER_24_1255 AVDD VSS sg13g2f_FILL8
XFILLER_24_1263 AVDD VSS sg13g2f_FILL4
XFILLER_24_1267 AVDD VSS sg13g2f_FILL1
XFILLER_24_1398 VDD VSS sg13g2f_FILL8
XFILLER_24_1406 VDD VSS sg13g2f_FILL8
XFILLER_24_1414 VDD VSS sg13g2f_FILL8
XFILLER_24_1422 VDD VSS sg13g2f_FILL8
XFILLER_24_1430 VDD VSS sg13g2f_FILL8
XFILLER_24_1438 VDD VSS sg13g2f_FILL8
XFILLER_24_1446 VDD VSS sg13g2f_FILL8
XFILLER_24_1454 VDD VSS sg13g2f_FILL8
XFILLER_24_1462 VDD VSS sg13g2f_FILL8
XFILLER_24_1470 VDD VSS sg13g2f_FILL8
XFILLER_24_1478 VDD VSS sg13g2f_FILL8
XFILLER_24_1486 VDD VSS sg13g2f_FILL8
XFILLER_24_1494 VDD VSS sg13g2f_FILL4
XFILLER_24_1513 VDD VSS sg13g2f_FILL8
XFILLER_24_1521 VDD VSS sg13g2f_FILL8
XFILLER_24_1529 VDD VSS sg13g2f_FILL8
XFILLER_24_1537 VDD VSS sg13g2f_FILL8
XFILLER_24_1545 VDD VSS sg13g2f_FILL4
XFILLER_24_1549 VDD VSS sg13g2f_FILL2
XFILLER_25_151 AVDD VSS sg13g2f_FILL8
XFILLER_25_159 AVDD VSS sg13g2f_FILL8
XFILLER_25_167 AVDD VSS sg13g2f_FILL8
XFILLER_25_175 AVDD VSS sg13g2f_FILL4
XFILLER_25_179 AVDD VSS sg13g2f_FILL1
XFILLER_25_205 AVDD VSS sg13g2f_FILL8
XFILLER_25_238 AVDD VSS sg13g2f_FILL8
XFILLER_25_246 AVDD VSS sg13g2f_FILL8
XFILLER_25_254 AVDD VSS sg13g2f_FILL8
XFILLER_25_262 AVDD VSS sg13g2f_FILL2
XFILLER_25_289 AVDD VSS sg13g2f_FILL8
XFILLER_25_297 AVDD VSS sg13g2f_FILL8
XFILLER_25_305 AVDD VSS sg13g2f_FILL8
XFILLER_25_313 AVDD VSS sg13g2f_FILL4
XFILLER_25_317 AVDD VSS sg13g2f_FILL2
XFILLER_25_319 AVDD VSS sg13g2f_FILL1
XFILLER_25_336 AVDD VSS sg13g2f_FILL2
XFILLER_25_368 AVDD VSS sg13g2f_FILL4
XFILLER_25_372 AVDD VSS sg13g2f_FILL2
XFILLER_25_374 AVDD VSS sg13g2f_FILL1
XFILLER_25_382 AVDD VSS sg13g2f_FILL2
XFILLER_25_427 AVDD VSS sg13g2f_FILL4
XFILLER_25_431 AVDD VSS sg13g2f_FILL2
XFILLER_25_433 AVDD VSS sg13g2f_FILL1
XFILLER_25_498 AVDD VSS sg13g2f_FILL8
XFILLER_25_506 AVDD VSS sg13g2f_FILL8
XFILLER_25_514 AVDD VSS sg13g2f_FILL8
XFILLER_25_522 AVDD VSS sg13g2f_FILL8
XFILLER_25_530 AVDD VSS sg13g2f_FILL8
XFILLER_25_538 AVDD VSS sg13g2f_FILL2
XFILLER_25_540 AVDD VSS sg13g2f_FILL1
XFILLER_25_605 AVDD VSS sg13g2f_FILL1
XFILLER_25_613 AVDD VSS sg13g2f_FILL8
XFILLER_25_621 AVDD VSS sg13g2f_FILL8
XFILLER_25_629 AVDD VSS sg13g2f_FILL2
XFILLER_25_631 AVDD VSS sg13g2f_FILL1
XFILLER_25_665 AVDD VSS sg13g2f_FILL8
XFILLER_25_673 AVDD VSS sg13g2f_FILL2
XFILLER_25_675 AVDD VSS sg13g2f_FILL1
XFILLER_25_740 AVDD VSS sg13g2f_FILL8
XFILLER_25_748 AVDD VSS sg13g2f_FILL8
XFILLER_25_820 AVDD VSS sg13g2f_FILL1
XFILLER_25_844 AVDD VSS sg13g2f_FILL1
XFILLER_25_870 AVDD VSS sg13g2f_FILL8
XFILLER_25_878 AVDD VSS sg13g2f_FILL2
XFILLER_25_960 AVDD VSS sg13g2f_FILL4
XFILLER_25_964 AVDD VSS sg13g2f_FILL1
XFILLER_25_986 AVDD VSS sg13g2f_FILL8
XFILLER_25_994 AVDD VSS sg13g2f_FILL8
XFILLER_25_1002 AVDD VSS sg13g2f_FILL8
XFILLER_25_1010 AVDD VSS sg13g2f_FILL4
XFILLER_25_1014 AVDD VSS sg13g2f_FILL2
XFILLER_25_1041 AVDD VSS sg13g2f_FILL2
XFILLER_25_1116 AVDD VSS sg13g2f_FILL8
XFILLER_25_1124 AVDD VSS sg13g2f_FILL4
XFILLER_25_1139 AVDD VSS sg13g2f_FILL2
XFILLER_25_1141 AVDD VSS sg13g2f_FILL1
XFILLER_25_1206 AVDD VSS sg13g2f_FILL8
XFILLER_25_1214 AVDD VSS sg13g2f_FILL8
XFILLER_25_1222 AVDD VSS sg13g2f_FILL8
XFILLER_25_1230 AVDD VSS sg13g2f_FILL8
XFILLER_25_1238 AVDD VSS sg13g2f_FILL8
XFILLER_25_1246 AVDD VSS sg13g2f_FILL8
XFILLER_25_1254 AVDD VSS sg13g2f_FILL8
XFILLER_25_1262 AVDD VSS sg13g2f_FILL4
XFILLER_25_1266 AVDD VSS sg13g2f_FILL2
XFILLER_25_1390 VDD VSS sg13g2f_FILL8
XFILLER_25_1398 VDD VSS sg13g2f_FILL8
XFILLER_25_1406 VDD VSS sg13g2f_FILL8
XFILLER_25_1414 VDD VSS sg13g2f_FILL8
XFILLER_25_1422 VDD VSS sg13g2f_FILL8
XFILLER_25_1430 VDD VSS sg13g2f_FILL8
XFILLER_25_1438 VDD VSS sg13g2f_FILL8
XFILLER_25_1446 VDD VSS sg13g2f_FILL8
XFILLER_25_1454 VDD VSS sg13g2f_FILL8
XFILLER_25_1462 VDD VSS sg13g2f_FILL8
XFILLER_25_1470 VDD VSS sg13g2f_FILL8
XFILLER_25_1478 VDD VSS sg13g2f_FILL8
XFILLER_25_1486 VDD VSS sg13g2f_FILL8
XFILLER_25_1494 VDD VSS sg13g2f_FILL8
XFILLER_25_1502 VDD VSS sg13g2f_FILL8
XFILLER_25_1510 VDD VSS sg13g2f_FILL4
XFILLER_25_1514 VDD VSS sg13g2f_FILL2
XFILLER_25_1535 VDD VSS sg13g2f_FILL8
XFILLER_25_1543 VDD VSS sg13g2f_FILL8
XFILLER_26_405 AVDD VSS sg13g2f_FILL4
XFILLER_26_409 AVDD VSS sg13g2f_FILL1
XFILLER_26_497 AVDD VSS sg13g2f_FILL8
XFILLER_26_505 AVDD VSS sg13g2f_FILL2
XFILLER_26_507 AVDD VSS sg13g2f_FILL1
XFILLER_26_524 AVDD VSS sg13g2f_FILL8
XFILLER_26_532 AVDD VSS sg13g2f_FILL1
XFILLER_26_622 AVDD VSS sg13g2f_FILL8
XFILLER_26_630 AVDD VSS sg13g2f_FILL8
XFILLER_26_638 AVDD VSS sg13g2f_FILL2
XFILLER_26_656 AVDD VSS sg13g2f_FILL1
XFILLER_26_744 AVDD VSS sg13g2f_FILL8
XFILLER_26_752 AVDD VSS sg13g2f_FILL4
XFILLER_26_772 AVDD VSS sg13g2f_FILL1
XFILLER_26_846 AVDD VSS sg13g2f_FILL4
XFILLER_26_850 AVDD VSS sg13g2f_FILL1
XFILLER_26_870 AVDD VSS sg13g2f_FILL8
XFILLER_26_878 AVDD VSS sg13g2f_FILL2
XFILLER_26_937 AVDD VSS sg13g2f_FILL4
XFILLER_26_970 AVDD VSS sg13g2f_FILL8
XFILLER_26_994 AVDD VSS sg13g2f_FILL8
XFILLER_26_1002 AVDD VSS sg13g2f_FILL8
XFILLER_26_1010 AVDD VSS sg13g2f_FILL8
XFILLER_26_1099 AVDD VSS sg13g2f_FILL8
XFILLER_26_1107 AVDD VSS sg13g2f_FILL8
XFILLER_26_1115 AVDD VSS sg13g2f_FILL8
XFILLER_26_1123 AVDD VSS sg13g2f_FILL8
XFILLER_26_1131 AVDD VSS sg13g2f_FILL4
XFILLER_26_1135 AVDD VSS sg13g2f_FILL2
XFILLER_26_1162 AVDD VSS sg13g2f_FILL2
XFILLER_26_1190 AVDD VSS sg13g2f_FILL8
XFILLER_26_1198 AVDD VSS sg13g2f_FILL4
XFILLER_26_1202 AVDD VSS sg13g2f_FILL2
XFILLER_26_1406 VDD VSS sg13g2f_FILL8
XFILLER_26_1414 VDD VSS sg13g2f_FILL8
XFILLER_26_1422 VDD VSS sg13g2f_FILL8
XFILLER_26_1430 VDD VSS sg13g2f_FILL8
XFILLER_26_1438 VDD VSS sg13g2f_FILL8
XFILLER_26_1446 VDD VSS sg13g2f_FILL8
XFILLER_26_1454 VDD VSS sg13g2f_FILL8
XFILLER_26_1462 VDD VSS sg13g2f_FILL8
XFILLER_26_1470 VDD VSS sg13g2f_FILL8
XFILLER_26_1478 VDD VSS sg13g2f_FILL4
XFILLER_26_1496 VDD VSS sg13g2f_FILL2
XFILLER_26_1547 VDD VSS sg13g2f_FILL4
XFILLER_27_430 AVDD VSS sg13g2f_FILL4
XFILLER_27_498 AVDD VSS sg13g2f_FILL8
XFILLER_27_506 AVDD VSS sg13g2f_FILL2
XFILLER_27_513 AVDD VSS sg13g2f_FILL4
XFILLER_27_613 AVDD VSS sg13g2f_FILL8
XFILLER_27_621 AVDD VSS sg13g2f_FILL8
XFILLER_27_629 AVDD VSS sg13g2f_FILL2
XFILLER_27_631 AVDD VSS sg13g2f_FILL1
XFILLER_27_665 AVDD VSS sg13g2f_FILL1
XFILLER_27_746 AVDD VSS sg13g2f_FILL8
XFILLER_27_754 AVDD VSS sg13g2f_FILL2
XFILLER_27_831 AVDD VSS sg13g2f_FILL4
XFILLER_27_835 AVDD VSS sg13g2f_FILL2
XFILLER_27_860 AVDD VSS sg13g2f_FILL8
XFILLER_27_868 AVDD VSS sg13g2f_FILL8
XFILLER_27_876 AVDD VSS sg13g2f_FILL4
XFILLER_27_880 AVDD VSS sg13g2f_FILL2
XFILLER_27_907 AVDD VSS sg13g2f_FILL8
XFILLER_27_915 AVDD VSS sg13g2f_FILL2
XFILLER_27_917 AVDD VSS sg13g2f_FILL1
XFILLER_27_987 AVDD VSS sg13g2f_FILL8
XFILLER_27_995 AVDD VSS sg13g2f_FILL8
XFILLER_27_1003 AVDD VSS sg13g2f_FILL4
XFILLER_27_1007 AVDD VSS sg13g2f_FILL2
XFILLER_27_1020 AVDD VSS sg13g2f_FILL2
XFILLER_27_1022 AVDD VSS sg13g2f_FILL1
XFILLER_27_1066 AVDD VSS sg13g2f_FILL2
XFILLER_27_1118 AVDD VSS sg13g2f_FILL8
XFILLER_27_1126 AVDD VSS sg13g2f_FILL2
XFILLER_27_1192 AVDD VSS sg13g2f_FILL8
XFILLER_27_1200 AVDD VSS sg13g2f_FILL8
XFILLER_27_1208 AVDD VSS sg13g2f_FILL8
XFILLER_27_1216 AVDD VSS sg13g2f_FILL8
XFILLER_27_1224 AVDD VSS sg13g2f_FILL8
XFILLER_27_1232 AVDD VSS sg13g2f_FILL8
XFILLER_27_1240 AVDD VSS sg13g2f_FILL8
XFILLER_27_1248 AVDD VSS sg13g2f_FILL8
XFILLER_27_1256 AVDD VSS sg13g2f_FILL8
XFILLER_27_1264 AVDD VSS sg13g2f_FILL4
XFILLER_27_1390 VDD VSS sg13g2f_FILL8
XFILLER_27_1398 VDD VSS sg13g2f_FILL8
XFILLER_27_1406 VDD VSS sg13g2f_FILL8
XFILLER_27_1414 VDD VSS sg13g2f_FILL8
XFILLER_27_1422 VDD VSS sg13g2f_FILL8
XFILLER_27_1430 VDD VSS sg13g2f_FILL8
XFILLER_27_1438 VDD VSS sg13g2f_FILL8
XFILLER_27_1446 VDD VSS sg13g2f_FILL8
XFILLER_27_1454 VDD VSS sg13g2f_FILL8
XFILLER_27_1462 VDD VSS sg13g2f_FILL8
XFILLER_27_1470 VDD VSS sg13g2f_FILL4
XFILLER_27_1516 VDD VSS sg13g2f_FILL8
XFILLER_27_1524 VDD VSS sg13g2f_FILL8
XFILLER_27_1532 VDD VSS sg13g2f_FILL8
XFILLER_27_1540 VDD VSS sg13g2f_FILL8
XFILLER_27_1548 VDD VSS sg13g2f_FILL2
XFILLER_27_1550 VDD VSS sg13g2f_FILL1
XFILLER_28_7 AVDD VSS sg13g2f_FILL4
XFILLER_28_11 AVDD VSS sg13g2f_FILL2
XFILLER_28_124 AVDD VSS sg13g2f_FILL8
XFILLER_28_132 AVDD VSS sg13g2f_FILL4
XFILLER_28_136 AVDD VSS sg13g2f_FILL2
XFILLER_28_138 AVDD VSS sg13g2f_FILL1
XFILLER_28_155 AVDD VSS sg13g2f_FILL2
XFILLER_28_190 AVDD VSS sg13g2f_FILL8
XFILLER_28_198 AVDD VSS sg13g2f_FILL8
XFILLER_28_206 AVDD VSS sg13g2f_FILL8
XFILLER_28_214 AVDD VSS sg13g2f_FILL8
XFILLER_28_222 AVDD VSS sg13g2f_FILL2
XFILLER_28_231 AVDD VSS sg13g2f_FILL8
XFILLER_28_239 AVDD VSS sg13g2f_FILL8
XFILLER_28_247 AVDD VSS sg13g2f_FILL8
XFILLER_28_255 AVDD VSS sg13g2f_FILL8
XFILLER_28_263 AVDD VSS sg13g2f_FILL8
XFILLER_28_271 AVDD VSS sg13g2f_FILL8
XFILLER_28_279 AVDD VSS sg13g2f_FILL8
XFILLER_28_287 AVDD VSS sg13g2f_FILL4
XFILLER_28_291 AVDD VSS sg13g2f_FILL2
XFILLER_28_293 AVDD VSS sg13g2f_FILL1
XFILLER_28_305 AVDD VSS sg13g2f_FILL8
XFILLER_28_313 AVDD VSS sg13g2f_FILL8
XFILLER_28_321 AVDD VSS sg13g2f_FILL8
XFILLER_28_329 AVDD VSS sg13g2f_FILL4
XFILLER_28_333 AVDD VSS sg13g2f_FILL2
XFILLER_28_335 AVDD VSS sg13g2f_FILL1
XFILLER_28_343 AVDD VSS sg13g2f_FILL4
XFILLER_28_374 AVDD VSS sg13g2f_FILL8
XFILLER_28_382 AVDD VSS sg13g2f_FILL2
XFILLER_28_455 AVDD VSS sg13g2f_FILL8
XFILLER_28_463 AVDD VSS sg13g2f_FILL1
XFILLER_28_496 AVDD VSS sg13g2f_FILL8
XFILLER_28_504 AVDD VSS sg13g2f_FILL8
XFILLER_28_512 AVDD VSS sg13g2f_FILL8
XFILLER_28_520 AVDD VSS sg13g2f_FILL4
XFILLER_28_567 AVDD VSS sg13g2f_FILL4
XFILLER_28_571 AVDD VSS sg13g2f_FILL2
XFILLER_28_573 AVDD VSS sg13g2f_FILL1
XFILLER_28_593 AVDD VSS sg13g2f_FILL4
XFILLER_28_597 AVDD VSS sg13g2f_FILL1
XFILLER_28_617 AVDD VSS sg13g2f_FILL8
XFILLER_28_625 AVDD VSS sg13g2f_FILL4
XFILLER_28_629 AVDD VSS sg13g2f_FILL2
XFILLER_28_631 AVDD VSS sg13g2f_FILL1
XFILLER_28_643 AVDD VSS sg13g2f_FILL8
XFILLER_28_651 AVDD VSS sg13g2f_FILL2
XFILLER_28_653 AVDD VSS sg13g2f_FILL1
XFILLER_28_670 AVDD VSS sg13g2f_FILL2
XFILLER_28_743 AVDD VSS sg13g2f_FILL8
XFILLER_28_751 AVDD VSS sg13g2f_FILL4
XFILLER_28_755 AVDD VSS sg13g2f_FILL1
XFILLER_28_778 AVDD VSS sg13g2f_FILL4
XFILLER_28_782 AVDD VSS sg13g2f_FILL2
XFILLER_28_791 AVDD VSS sg13g2f_FILL8
XFILLER_28_799 AVDD VSS sg13g2f_FILL4
XFILLER_28_803 AVDD VSS sg13g2f_FILL2
XFILLER_28_805 AVDD VSS sg13g2f_FILL1
XFILLER_28_870 AVDD VSS sg13g2f_FILL8
XFILLER_28_878 AVDD VSS sg13g2f_FILL2
XFILLER_28_891 AVDD VSS sg13g2f_FILL4
XFILLER_28_895 AVDD VSS sg13g2f_FILL1
XFILLER_28_914 AVDD VSS sg13g2f_FILL1
XFILLER_28_990 AVDD VSS sg13g2f_FILL8
XFILLER_28_998 AVDD VSS sg13g2f_FILL8
XFILLER_28_1006 AVDD VSS sg13g2f_FILL2
XFILLER_28_1015 AVDD VSS sg13g2f_FILL1
XFILLER_28_1059 AVDD VSS sg13g2f_FILL4
XFILLER_28_1063 AVDD VSS sg13g2f_FILL2
XFILLER_28_1081 AVDD VSS sg13g2f_FILL1
XFILLER_28_1118 AVDD VSS sg13g2f_FILL2
XFILLER_28_1127 AVDD VSS sg13g2f_FILL1
XFILLER_28_1182 AVDD VSS sg13g2f_FILL8
XFILLER_28_1190 AVDD VSS sg13g2f_FILL8
XFILLER_28_1198 AVDD VSS sg13g2f_FILL8
XFILLER_28_1206 AVDD VSS sg13g2f_FILL8
XFILLER_28_1214 AVDD VSS sg13g2f_FILL8
XFILLER_28_1222 AVDD VSS sg13g2f_FILL8
XFILLER_28_1230 AVDD VSS sg13g2f_FILL2
XFILLER_28_1239 AVDD VSS sg13g2f_FILL8
XFILLER_28_1247 AVDD VSS sg13g2f_FILL8
XFILLER_28_1255 AVDD VSS sg13g2f_FILL8
XFILLER_28_1263 AVDD VSS sg13g2f_FILL4
XFILLER_28_1267 AVDD VSS sg13g2f_FILL1
XFILLER_28_1390 VDD VSS sg13g2f_FILL8
XFILLER_28_1398 VDD VSS sg13g2f_FILL8
XFILLER_28_1406 VDD VSS sg13g2f_FILL8
XFILLER_28_1414 VDD VSS sg13g2f_FILL8
XFILLER_28_1422 VDD VSS sg13g2f_FILL8
XFILLER_28_1430 VDD VSS sg13g2f_FILL8
XFILLER_28_1438 VDD VSS sg13g2f_FILL8
XFILLER_28_1446 VDD VSS sg13g2f_FILL8
XFILLER_28_1454 VDD VSS sg13g2f_FILL8
XFILLER_28_1462 VDD VSS sg13g2f_FILL8
XFILLER_28_1470 VDD VSS sg13g2f_FILL8
XFILLER_28_1478 VDD VSS sg13g2f_FILL8
XFILLER_28_1486 VDD VSS sg13g2f_FILL1
XFILLER_28_1513 VDD VSS sg13g2f_FILL8
XFILLER_28_1521 VDD VSS sg13g2f_FILL8
XFILLER_28_1529 VDD VSS sg13g2f_FILL8
XFILLER_28_1537 VDD VSS sg13g2f_FILL8
XFILLER_28_1545 VDD VSS sg13g2f_FILL4
XFILLER_28_1549 VDD VSS sg13g2f_FILL2
XFILLER_29_7 AVDD VSS sg13g2f_FILL4
XFILLER_29_11 AVDD VSS sg13g2f_FILL1
XFILLER_29_76 AVDD VSS sg13g2f_FILL8
XFILLER_29_84 AVDD VSS sg13g2f_FILL8
XFILLER_29_92 AVDD VSS sg13g2f_FILL8
XFILLER_29_100 AVDD VSS sg13g2f_FILL8
XFILLER_29_108 AVDD VSS sg13g2f_FILL8
XFILLER_29_116 AVDD VSS sg13g2f_FILL8
XFILLER_29_124 AVDD VSS sg13g2f_FILL8
XFILLER_29_132 AVDD VSS sg13g2f_FILL4
XFILLER_29_152 AVDD VSS sg13g2f_FILL4
XFILLER_29_156 AVDD VSS sg13g2f_FILL1
XFILLER_29_168 AVDD VSS sg13g2f_FILL8
XFILLER_29_176 AVDD VSS sg13g2f_FILL8
XFILLER_29_184 AVDD VSS sg13g2f_FILL8
XFILLER_29_192 AVDD VSS sg13g2f_FILL8
XFILLER_29_200 AVDD VSS sg13g2f_FILL8
XFILLER_29_208 AVDD VSS sg13g2f_FILL8
XFILLER_29_216 AVDD VSS sg13g2f_FILL8
XFILLER_29_224 AVDD VSS sg13g2f_FILL4
XFILLER_29_228 AVDD VSS sg13g2f_FILL2
XFILLER_29_230 AVDD VSS sg13g2f_FILL1
XFILLER_29_238 AVDD VSS sg13g2f_FILL8
XFILLER_29_246 AVDD VSS sg13g2f_FILL8
XFILLER_29_254 AVDD VSS sg13g2f_FILL8
XFILLER_29_262 AVDD VSS sg13g2f_FILL8
XFILLER_29_270 AVDD VSS sg13g2f_FILL8
XFILLER_29_278 AVDD VSS sg13g2f_FILL8
XFILLER_29_286 AVDD VSS sg13g2f_FILL8
XFILLER_29_294 AVDD VSS sg13g2f_FILL8
XFILLER_29_302 AVDD VSS sg13g2f_FILL8
XFILLER_29_310 AVDD VSS sg13g2f_FILL8
XFILLER_29_318 AVDD VSS sg13g2f_FILL8
XFILLER_29_326 AVDD VSS sg13g2f_FILL8
XFILLER_29_334 AVDD VSS sg13g2f_FILL8
XFILLER_29_342 AVDD VSS sg13g2f_FILL8
XFILLER_29_350 AVDD VSS sg13g2f_FILL8
XFILLER_29_358 AVDD VSS sg13g2f_FILL1
XFILLER_29_364 AVDD VSS sg13g2f_FILL8
XFILLER_29_372 AVDD VSS sg13g2f_FILL8
XFILLER_29_380 AVDD VSS sg13g2f_FILL4
XFILLER_29_448 AVDD VSS sg13g2f_FILL2
XFILLER_29_450 AVDD VSS sg13g2f_FILL1
XFILLER_29_485 AVDD VSS sg13g2f_FILL8
XFILLER_29_493 AVDD VSS sg13g2f_FILL8
XFILLER_29_501 AVDD VSS sg13g2f_FILL8
XFILLER_29_509 AVDD VSS sg13g2f_FILL4
XFILLER_29_593 AVDD VSS sg13g2f_FILL4
XFILLER_29_613 AVDD VSS sg13g2f_FILL8
XFILLER_29_621 AVDD VSS sg13g2f_FILL8
XFILLER_29_629 AVDD VSS sg13g2f_FILL8
XFILLER_29_637 AVDD VSS sg13g2f_FILL8
XFILLER_29_645 AVDD VSS sg13g2f_FILL8
XFILLER_29_653 AVDD VSS sg13g2f_FILL8
XFILLER_29_661 AVDD VSS sg13g2f_FILL1
XFILLER_29_673 AVDD VSS sg13g2f_FILL4
XFILLER_29_741 AVDD VSS sg13g2f_FILL8
XFILLER_29_749 AVDD VSS sg13g2f_FILL8
XFILLER_29_757 AVDD VSS sg13g2f_FILL8
XFILLER_29_765 AVDD VSS sg13g2f_FILL8
XFILLER_29_773 AVDD VSS sg13g2f_FILL8
XFILLER_29_781 AVDD VSS sg13g2f_FILL8
XFILLER_29_789 AVDD VSS sg13g2f_FILL4
XFILLER_29_793 AVDD VSS sg13g2f_FILL2
XFILLER_29_827 AVDD VSS sg13g2f_FILL2
XFILLER_29_829 AVDD VSS sg13g2f_FILL1
XFILLER_29_855 AVDD VSS sg13g2f_FILL2
XFILLER_29_868 AVDD VSS sg13g2f_FILL8
XFILLER_29_876 AVDD VSS sg13g2f_FILL8
XFILLER_29_909 AVDD VSS sg13g2f_FILL4
XFILLER_29_931 AVDD VSS sg13g2f_FILL8
XFILLER_29_939 AVDD VSS sg13g2f_FILL8
XFILLER_29_947 AVDD VSS sg13g2f_FILL1
XFILLER_29_991 AVDD VSS sg13g2f_FILL8
XFILLER_29_999 AVDD VSS sg13g2f_FILL8
XFILLER_29_1007 AVDD VSS sg13g2f_FILL4
XFILLER_29_1011 AVDD VSS sg13g2f_FILL2
XFILLER_29_1013 AVDD VSS sg13g2f_FILL1
XFILLER_29_1047 AVDD VSS sg13g2f_FILL8
XFILLER_29_1055 AVDD VSS sg13g2f_FILL8
XFILLER_29_1063 AVDD VSS sg13g2f_FILL8
XFILLER_29_1071 AVDD VSS sg13g2f_FILL4
XFILLER_29_1118 AVDD VSS sg13g2f_FILL8
XFILLER_29_1126 AVDD VSS sg13g2f_FILL8
XFILLER_29_1134 AVDD VSS sg13g2f_FILL1
XFILLER_29_1151 AVDD VSS sg13g2f_FILL4
XFILLER_29_1173 AVDD VSS sg13g2f_FILL8
XFILLER_29_1181 AVDD VSS sg13g2f_FILL8
XFILLER_29_1189 AVDD VSS sg13g2f_FILL8
XFILLER_29_1197 AVDD VSS sg13g2f_FILL8
XFILLER_29_1205 AVDD VSS sg13g2f_FILL8
XFILLER_29_1213 AVDD VSS sg13g2f_FILL8
XFILLER_29_1221 AVDD VSS sg13g2f_FILL8
XFILLER_29_1229 AVDD VSS sg13g2f_FILL8
XFILLER_29_1237 AVDD VSS sg13g2f_FILL8
XFILLER_29_1245 AVDD VSS sg13g2f_FILL8
XFILLER_29_1253 AVDD VSS sg13g2f_FILL8
XFILLER_29_1261 AVDD VSS sg13g2f_FILL4
XFILLER_29_1265 AVDD VSS sg13g2f_FILL2
XFILLER_29_1267 AVDD VSS sg13g2f_FILL1
XFILLER_29_1390 VDD VSS sg13g2f_FILL8
XFILLER_29_1398 VDD VSS sg13g2f_FILL8
XFILLER_29_1406 VDD VSS sg13g2f_FILL8
XFILLER_29_1414 VDD VSS sg13g2f_FILL8
XFILLER_29_1422 VDD VSS sg13g2f_FILL8
XFILLER_29_1430 VDD VSS sg13g2f_FILL8
XFILLER_29_1438 VDD VSS sg13g2f_FILL8
XFILLER_29_1446 VDD VSS sg13g2f_FILL8
XFILLER_29_1454 VDD VSS sg13g2f_FILL8
XFILLER_29_1462 VDD VSS sg13g2f_FILL8
XFILLER_29_1470 VDD VSS sg13g2f_FILL4
XFILLER_29_1474 VDD VSS sg13g2f_FILL1
XFILLER_29_1528 VDD VSS sg13g2f_FILL8
XFILLER_29_1536 VDD VSS sg13g2f_FILL8
XFILLER_29_1544 VDD VSS sg13g2f_FILL4
XFILLER_29_1548 VDD VSS sg13g2f_FILL2
XFILLER_29_1550 VDD VSS sg13g2f_FILL1
XFILLER_30_7 AVDD VSS sg13g2f_FILL8
XFILLER_30_15 AVDD VSS sg13g2f_FILL8
XFILLER_30_23 AVDD VSS sg13g2f_FILL2
XFILLER_30_25 AVDD VSS sg13g2f_FILL1
XFILLER_30_47 AVDD VSS sg13g2f_FILL1
XFILLER_30_119 AVDD VSS sg13g2f_FILL8
XFILLER_30_127 AVDD VSS sg13g2f_FILL8
XFILLER_30_135 AVDD VSS sg13g2f_FILL8
XFILLER_30_143 AVDD VSS sg13g2f_FILL8
XFILLER_30_151 AVDD VSS sg13g2f_FILL8
XFILLER_30_159 AVDD VSS sg13g2f_FILL8
XFILLER_30_167 AVDD VSS sg13g2f_FILL8
XFILLER_30_175 AVDD VSS sg13g2f_FILL8
XFILLER_30_183 AVDD VSS sg13g2f_FILL8
XFILLER_30_191 AVDD VSS sg13g2f_FILL8
XFILLER_30_199 AVDD VSS sg13g2f_FILL8
XFILLER_30_207 AVDD VSS sg13g2f_FILL8
XFILLER_30_215 AVDD VSS sg13g2f_FILL8
XFILLER_30_223 AVDD VSS sg13g2f_FILL1
XFILLER_30_231 AVDD VSS sg13g2f_FILL8
XFILLER_30_239 AVDD VSS sg13g2f_FILL8
XFILLER_30_247 AVDD VSS sg13g2f_FILL8
XFILLER_30_255 AVDD VSS sg13g2f_FILL8
XFILLER_30_263 AVDD VSS sg13g2f_FILL8
XFILLER_30_271 AVDD VSS sg13g2f_FILL8
XFILLER_30_279 AVDD VSS sg13g2f_FILL8
XFILLER_30_287 AVDD VSS sg13g2f_FILL8
XFILLER_30_295 AVDD VSS sg13g2f_FILL8
XFILLER_30_303 AVDD VSS sg13g2f_FILL8
XFILLER_30_311 AVDD VSS sg13g2f_FILL8
XFILLER_30_319 AVDD VSS sg13g2f_FILL8
XFILLER_30_327 AVDD VSS sg13g2f_FILL8
XFILLER_30_335 AVDD VSS sg13g2f_FILL1
XFILLER_30_343 AVDD VSS sg13g2f_FILL8
XFILLER_30_351 AVDD VSS sg13g2f_FILL8
XFILLER_30_359 AVDD VSS sg13g2f_FILL8
XFILLER_30_367 AVDD VSS sg13g2f_FILL8
XFILLER_30_375 AVDD VSS sg13g2f_FILL8
XFILLER_30_383 AVDD VSS sg13g2f_FILL1
XFILLER_30_455 AVDD VSS sg13g2f_FILL1
XFILLER_30_467 AVDD VSS sg13g2f_FILL8
XFILLER_30_475 AVDD VSS sg13g2f_FILL8
XFILLER_30_483 AVDD VSS sg13g2f_FILL8
XFILLER_30_491 AVDD VSS sg13g2f_FILL8
XFILLER_30_499 AVDD VSS sg13g2f_FILL8
XFILLER_30_507 AVDD VSS sg13g2f_FILL8
XFILLER_30_515 AVDD VSS sg13g2f_FILL8
XFILLER_30_523 AVDD VSS sg13g2f_FILL8
XFILLER_30_531 AVDD VSS sg13g2f_FILL8
XFILLER_30_539 AVDD VSS sg13g2f_FILL8
XFILLER_30_547 AVDD VSS sg13g2f_FILL8
XFILLER_30_555 AVDD VSS sg13g2f_FILL4
XFILLER_30_559 AVDD VSS sg13g2f_FILL1
XFILLER_30_567 AVDD VSS sg13g2f_FILL8
XFILLER_30_575 AVDD VSS sg13g2f_FILL8
XFILLER_30_583 AVDD VSS sg13g2f_FILL8
XFILLER_30_591 AVDD VSS sg13g2f_FILL8
XFILLER_30_599 AVDD VSS sg13g2f_FILL8
XFILLER_30_607 AVDD VSS sg13g2f_FILL8
XFILLER_30_615 AVDD VSS sg13g2f_FILL8
XFILLER_30_623 AVDD VSS sg13g2f_FILL8
XFILLER_30_631 AVDD VSS sg13g2f_FILL8
XFILLER_30_639 AVDD VSS sg13g2f_FILL8
XFILLER_30_647 AVDD VSS sg13g2f_FILL8
XFILLER_30_655 AVDD VSS sg13g2f_FILL8
XFILLER_30_663 AVDD VSS sg13g2f_FILL8
XFILLER_30_671 AVDD VSS sg13g2f_FILL1
XFILLER_30_679 AVDD VSS sg13g2f_FILL8
XFILLER_30_687 AVDD VSS sg13g2f_FILL8
XFILLER_30_695 AVDD VSS sg13g2f_FILL8
XFILLER_30_714 AVDD VSS sg13g2f_FILL8
XFILLER_30_722 AVDD VSS sg13g2f_FILL8
XFILLER_30_730 AVDD VSS sg13g2f_FILL8
XFILLER_30_738 AVDD VSS sg13g2f_FILL8
XFILLER_30_746 AVDD VSS sg13g2f_FILL8
XFILLER_30_754 AVDD VSS sg13g2f_FILL8
XFILLER_30_762 AVDD VSS sg13g2f_FILL8
XFILLER_30_770 AVDD VSS sg13g2f_FILL8
XFILLER_30_778 AVDD VSS sg13g2f_FILL4
XFILLER_30_782 AVDD VSS sg13g2f_FILL2
XFILLER_30_791 AVDD VSS sg13g2f_FILL8
XFILLER_30_799 AVDD VSS sg13g2f_FILL8
XFILLER_30_807 AVDD VSS sg13g2f_FILL8
XFILLER_30_815 AVDD VSS sg13g2f_FILL8
XFILLER_30_823 AVDD VSS sg13g2f_FILL8
XFILLER_30_831 AVDD VSS sg13g2f_FILL8
XFILLER_30_839 AVDD VSS sg13g2f_FILL8
XFILLER_30_847 AVDD VSS sg13g2f_FILL8
XFILLER_30_855 AVDD VSS sg13g2f_FILL8
XFILLER_30_863 AVDD VSS sg13g2f_FILL8
XFILLER_30_871 AVDD VSS sg13g2f_FILL8
XFILLER_30_879 AVDD VSS sg13g2f_FILL8
XFILLER_30_887 AVDD VSS sg13g2f_FILL8
XFILLER_30_895 AVDD VSS sg13g2f_FILL1
XFILLER_30_903 AVDD VSS sg13g2f_FILL8
XFILLER_30_911 AVDD VSS sg13g2f_FILL8
XFILLER_30_919 AVDD VSS sg13g2f_FILL8
XFILLER_30_927 AVDD VSS sg13g2f_FILL8
XFILLER_30_935 AVDD VSS sg13g2f_FILL8
XFILLER_30_943 AVDD VSS sg13g2f_FILL8
XFILLER_30_951 AVDD VSS sg13g2f_FILL8
XFILLER_30_959 AVDD VSS sg13g2f_FILL8
XFILLER_30_967 AVDD VSS sg13g2f_FILL1
XFILLER_30_979 AVDD VSS sg13g2f_FILL8
XFILLER_30_987 AVDD VSS sg13g2f_FILL8
XFILLER_30_995 AVDD VSS sg13g2f_FILL8
XFILLER_30_1003 AVDD VSS sg13g2f_FILL4
XFILLER_30_1007 AVDD VSS sg13g2f_FILL1
XFILLER_30_1015 AVDD VSS sg13g2f_FILL8
XFILLER_30_1023 AVDD VSS sg13g2f_FILL8
XFILLER_30_1031 AVDD VSS sg13g2f_FILL8
XFILLER_30_1039 AVDD VSS sg13g2f_FILL8
XFILLER_30_1047 AVDD VSS sg13g2f_FILL8
XFILLER_30_1055 AVDD VSS sg13g2f_FILL8
XFILLER_30_1063 AVDD VSS sg13g2f_FILL8
XFILLER_30_1071 AVDD VSS sg13g2f_FILL8
XFILLER_30_1079 AVDD VSS sg13g2f_FILL8
XFILLER_30_1087 AVDD VSS sg13g2f_FILL8
XFILLER_30_1095 AVDD VSS sg13g2f_FILL8
XFILLER_30_1103 AVDD VSS sg13g2f_FILL8
XFILLER_30_1111 AVDD VSS sg13g2f_FILL8
XFILLER_30_1119 AVDD VSS sg13g2f_FILL1
XFILLER_30_1127 AVDD VSS sg13g2f_FILL8
XFILLER_30_1135 AVDD VSS sg13g2f_FILL8
XFILLER_30_1143 AVDD VSS sg13g2f_FILL8
XFILLER_30_1151 AVDD VSS sg13g2f_FILL8
XFILLER_30_1159 AVDD VSS sg13g2f_FILL8
XFILLER_30_1167 AVDD VSS sg13g2f_FILL8
XFILLER_30_1175 AVDD VSS sg13g2f_FILL8
XFILLER_30_1183 AVDD VSS sg13g2f_FILL8
XFILLER_30_1191 AVDD VSS sg13g2f_FILL8
XFILLER_30_1199 AVDD VSS sg13g2f_FILL8
XFILLER_30_1207 AVDD VSS sg13g2f_FILL8
XFILLER_30_1215 AVDD VSS sg13g2f_FILL8
XFILLER_30_1223 AVDD VSS sg13g2f_FILL8
XFILLER_30_1231 AVDD VSS sg13g2f_FILL1
XFILLER_30_1239 AVDD VSS sg13g2f_FILL8
XFILLER_30_1247 AVDD VSS sg13g2f_FILL8
XFILLER_30_1255 AVDD VSS sg13g2f_FILL8
XFILLER_30_1263 AVDD VSS sg13g2f_FILL4
XFILLER_30_1267 AVDD VSS sg13g2f_FILL1
XFILLER_30_1390 VDD VSS sg13g2f_FILL8
XFILLER_30_1398 VDD VSS sg13g2f_FILL8
XFILLER_30_1406 VDD VSS sg13g2f_FILL8
XFILLER_30_1414 VDD VSS sg13g2f_FILL8
XFILLER_30_1422 VDD VSS sg13g2f_FILL8
XFILLER_30_1430 VDD VSS sg13g2f_FILL8
XFILLER_30_1438 VDD VSS sg13g2f_FILL8
XFILLER_30_1446 VDD VSS sg13g2f_FILL8
XFILLER_30_1454 VDD VSS sg13g2f_FILL2
XFILLER_30_1547 VDD VSS sg13g2f_FILL4
XFILLER_31_1390 VDD VSS sg13g2f_FILL8
XFILLER_31_1398 VDD VSS sg13g2f_FILL8
XFILLER_31_1406 VDD VSS sg13g2f_FILL8
XFILLER_31_1414 VDD VSS sg13g2f_FILL8
XFILLER_31_1422 VDD VSS sg13g2f_FILL8
XFILLER_31_1430 VDD VSS sg13g2f_FILL8
XFILLER_31_1438 VDD VSS sg13g2f_FILL8
XFILLER_31_1446 VDD VSS sg13g2f_FILL8
XFILLER_31_1454 VDD VSS sg13g2f_FILL8
XFILLER_31_1462 VDD VSS sg13g2f_FILL8
XFILLER_31_1470 VDD VSS sg13g2f_FILL8
XFILLER_31_1478 VDD VSS sg13g2f_FILL8
XFILLER_31_1486 VDD VSS sg13g2f_FILL8
XFILLER_31_1494 VDD VSS sg13g2f_FILL8
XFILLER_31_1502 VDD VSS sg13g2f_FILL4
XFILLER_31_1517 VDD VSS sg13g2f_FILL8
XFILLER_31_1525 VDD VSS sg13g2f_FILL8
XFILLER_31_1533 VDD VSS sg13g2f_FILL8
XFILLER_31_1541 VDD VSS sg13g2f_FILL8
XFILLER_31_1549 VDD VSS sg13g2f_FILL2
XFILLER_32_1390 VDD VSS sg13g2f_FILL8
XFILLER_32_1398 VDD VSS sg13g2f_FILL8
XFILLER_32_1406 VDD VSS sg13g2f_FILL8
XFILLER_32_1414 VDD VSS sg13g2f_FILL8
XFILLER_32_1422 VDD VSS sg13g2f_FILL8
XFILLER_32_1430 VDD VSS sg13g2f_FILL8
XFILLER_32_1438 VDD VSS sg13g2f_FILL8
XFILLER_32_1446 VDD VSS sg13g2f_FILL8
XFILLER_32_1454 VDD VSS sg13g2f_FILL8
XFILLER_32_1462 VDD VSS sg13g2f_FILL8
XFILLER_32_1470 VDD VSS sg13g2f_FILL8
XFILLER_32_1478 VDD VSS sg13g2f_FILL8
XFILLER_32_1486 VDD VSS sg13g2f_FILL8
XFILLER_32_1494 VDD VSS sg13g2f_FILL4
XFILLER_32_1516 VDD VSS sg13g2f_FILL8
XFILLER_32_1524 VDD VSS sg13g2f_FILL8
XFILLER_32_1532 VDD VSS sg13g2f_FILL8
XFILLER_32_1540 VDD VSS sg13g2f_FILL8
XFILLER_32_1548 VDD VSS sg13g2f_FILL2
XFILLER_32_1550 VDD VSS sg13g2f_FILL1
XFILLER_33_1390 VDD VSS sg13g2f_FILL8
XFILLER_33_1398 VDD VSS sg13g2f_FILL8
XFILLER_33_1406 VDD VSS sg13g2f_FILL8
XFILLER_33_1414 VDD VSS sg13g2f_FILL8
XFILLER_33_1422 VDD VSS sg13g2f_FILL8
XFILLER_33_1430 VDD VSS sg13g2f_FILL8
XFILLER_33_1438 VDD VSS sg13g2f_FILL8
XFILLER_33_1446 VDD VSS sg13g2f_FILL8
XFILLER_33_1454 VDD VSS sg13g2f_FILL8
XFILLER_33_1462 VDD VSS sg13g2f_FILL8
XFILLER_33_1470 VDD VSS sg13g2f_FILL4
XFILLER_33_1474 VDD VSS sg13g2f_FILL1
XFILLER_33_1531 VDD VSS sg13g2f_FILL8
XFILLER_33_1539 VDD VSS sg13g2f_FILL8
XFILLER_33_1547 VDD VSS sg13g2f_FILL4
XFILLER_34_1390 VDD VSS sg13g2f_FILL8
XFILLER_34_1398 VDD VSS sg13g2f_FILL8
XFILLER_34_1406 VDD VSS sg13g2f_FILL8
XFILLER_34_1414 VDD VSS sg13g2f_FILL8
XFILLER_34_1422 VDD VSS sg13g2f_FILL8
XFILLER_34_1430 VDD VSS sg13g2f_FILL8
XFILLER_34_1438 VDD VSS sg13g2f_FILL8
XFILLER_34_1446 VDD VSS sg13g2f_FILL8
XFILLER_34_1454 VDD VSS sg13g2f_FILL8
XFILLER_34_1462 VDD VSS sg13g2f_FILL8
XFILLER_34_1470 VDD VSS sg13g2f_FILL8
XFILLER_34_1478 VDD VSS sg13g2f_FILL8
XFILLER_34_1486 VDD VSS sg13g2f_FILL8
XFILLER_34_1494 VDD VSS sg13g2f_FILL4
XFILLER_34_1505 VDD VSS sg13g2f_FILL4
XFILLER_34_1520 VDD VSS sg13g2f_FILL8
XFILLER_34_1528 VDD VSS sg13g2f_FILL8
XFILLER_34_1536 VDD VSS sg13g2f_FILL8
XFILLER_34_1544 VDD VSS sg13g2f_FILL4
XFILLER_34_1548 VDD VSS sg13g2f_FILL2
XFILLER_34_1550 VDD VSS sg13g2f_FILL1
XFILLER_35_1390 VDD VSS sg13g2f_FILL8
XFILLER_35_1398 VDD VSS sg13g2f_FILL8
XFILLER_35_1406 VDD VSS sg13g2f_FILL8
XFILLER_35_1414 VDD VSS sg13g2f_FILL8
XFILLER_35_1422 VDD VSS sg13g2f_FILL8
XFILLER_35_1430 VDD VSS sg13g2f_FILL8
XFILLER_35_1438 VDD VSS sg13g2f_FILL8
XFILLER_35_1446 VDD VSS sg13g2f_FILL8
XFILLER_35_1454 VDD VSS sg13g2f_FILL8
XFILLER_35_1462 VDD VSS sg13g2f_FILL8
XFILLER_35_1470 VDD VSS sg13g2f_FILL8
XFILLER_35_1478 VDD VSS sg13g2f_FILL8
XFILLER_35_1486 VDD VSS sg13g2f_FILL8
XFILLER_35_1536 VDD VSS sg13g2f_FILL8
XFILLER_35_1544 VDD VSS sg13g2f_FILL4
XFILLER_35_1548 VDD VSS sg13g2f_FILL2
XFILLER_35_1550 VDD VSS sg13g2f_FILL1
XFILLER_36_1390 VDD VSS sg13g2f_FILL8
XFILLER_36_1398 VDD VSS sg13g2f_FILL8
XFILLER_36_1406 VDD VSS sg13g2f_FILL8
XFILLER_36_1414 VDD VSS sg13g2f_FILL8
XFILLER_36_1422 VDD VSS sg13g2f_FILL8
XFILLER_36_1430 VDD VSS sg13g2f_FILL8
XFILLER_36_1438 VDD VSS sg13g2f_FILL8
XFILLER_36_1446 VDD VSS sg13g2f_FILL8
XFILLER_36_1454 VDD VSS sg13g2f_FILL8
XFILLER_36_1462 VDD VSS sg13g2f_FILL8
XFILLER_36_1470 VDD VSS sg13g2f_FILL8
XFILLER_36_1478 VDD VSS sg13g2f_FILL8
XFILLER_36_1486 VDD VSS sg13g2f_FILL8
XFILLER_36_1494 VDD VSS sg13g2f_FILL4
XFILLER_36_1505 VDD VSS sg13g2f_FILL4
XFILLER_36_1509 VDD VSS sg13g2f_FILL2
XFILLER_36_1511 VDD VSS sg13g2f_FILL1
XFILLER_36_1545 VDD VSS sg13g2f_FILL4
XFILLER_36_1549 VDD VSS sg13g2f_FILL2
XFILLER_37_1390 VDD VSS sg13g2f_FILL8
XFILLER_37_1398 VDD VSS sg13g2f_FILL8
XFILLER_37_1406 VDD VSS sg13g2f_FILL8
XFILLER_37_1414 VDD VSS sg13g2f_FILL8
XFILLER_37_1422 VDD VSS sg13g2f_FILL8
XFILLER_37_1430 VDD VSS sg13g2f_FILL8
XFILLER_37_1438 VDD VSS sg13g2f_FILL8
XFILLER_37_1446 VDD VSS sg13g2f_FILL8
XFILLER_37_1454 VDD VSS sg13g2f_FILL8
XFILLER_37_1462 VDD VSS sg13g2f_FILL8
XFILLER_37_1470 VDD VSS sg13g2f_FILL8
XFILLER_37_1478 VDD VSS sg13g2f_FILL8
XFILLER_37_1486 VDD VSS sg13g2f_FILL8
XFILLER_37_1494 VDD VSS sg13g2f_FILL8
XFILLER_37_1502 VDD VSS sg13g2f_FILL8
XFILLER_37_1510 VDD VSS sg13g2f_FILL4
XFILLER_37_1525 VDD VSS sg13g2f_FILL8
XFILLER_37_1533 VDD VSS sg13g2f_FILL8
XFILLER_37_1541 VDD VSS sg13g2f_FILL8
XFILLER_37_1549 VDD VSS sg13g2f_FILL2
XFILLER_38_1390 VDD VSS sg13g2f_FILL8
XFILLER_38_1398 VDD VSS sg13g2f_FILL8
XFILLER_38_1406 VDD VSS sg13g2f_FILL8
XFILLER_38_1414 VDD VSS sg13g2f_FILL8
XFILLER_38_1422 VDD VSS sg13g2f_FILL8
XFILLER_38_1430 VDD VSS sg13g2f_FILL8
XFILLER_38_1438 VDD VSS sg13g2f_FILL8
XFILLER_38_1446 VDD VSS sg13g2f_FILL8
XFILLER_38_1454 VDD VSS sg13g2f_FILL8
XFILLER_38_1462 VDD VSS sg13g2f_FILL8
XFILLER_38_1470 VDD VSS sg13g2f_FILL8
XFILLER_38_1478 VDD VSS sg13g2f_FILL8
XFILLER_38_1486 VDD VSS sg13g2f_FILL8
XFILLER_38_1494 VDD VSS sg13g2f_FILL4
XFILLER_38_1505 VDD VSS sg13g2f_FILL8
XFILLER_38_1513 VDD VSS sg13g2f_FILL1
XFILLER_38_1528 VDD VSS sg13g2f_FILL8
XFILLER_38_1536 VDD VSS sg13g2f_FILL8
XFILLER_38_1544 VDD VSS sg13g2f_FILL4
XFILLER_38_1548 VDD VSS sg13g2f_FILL2
XFILLER_38_1550 VDD VSS sg13g2f_FILL1
XFILLER_39_1390 VDD VSS sg13g2f_FILL8
XFILLER_39_1398 VDD VSS sg13g2f_FILL8
XFILLER_39_1406 VDD VSS sg13g2f_FILL8
XFILLER_39_1414 VDD VSS sg13g2f_FILL8
XFILLER_39_1422 VDD VSS sg13g2f_FILL8
XFILLER_39_1430 VDD VSS sg13g2f_FILL8
XFILLER_39_1438 VDD VSS sg13g2f_FILL8
XFILLER_39_1446 VDD VSS sg13g2f_FILL8
XFILLER_39_1454 VDD VSS sg13g2f_FILL8
XFILLER_39_1462 VDD VSS sg13g2f_FILL8
XFILLER_39_1470 VDD VSS sg13g2f_FILL8
XFILLER_39_1478 VDD VSS sg13g2f_FILL8
XFILLER_39_1486 VDD VSS sg13g2f_FILL8
XFILLER_39_1494 VDD VSS sg13g2f_FILL8
XFILLER_39_1502 VDD VSS sg13g2f_FILL8
XFILLER_39_1510 VDD VSS sg13g2f_FILL4
XFILLER_39_1514 VDD VSS sg13g2f_FILL1
XFILLER_39_1526 VDD VSS sg13g2f_FILL8
XFILLER_39_1534 VDD VSS sg13g2f_FILL8
XFILLER_39_1542 VDD VSS sg13g2f_FILL8
XFILLER_39_1550 VDD VSS sg13g2f_FILL1
XFILLER_40_1390 VDD VSS sg13g2f_FILL8
XFILLER_40_1398 VDD VSS sg13g2f_FILL8
XFILLER_40_1406 VDD VSS sg13g2f_FILL8
XFILLER_40_1414 VDD VSS sg13g2f_FILL8
XFILLER_40_1422 VDD VSS sg13g2f_FILL8
XFILLER_40_1430 VDD VSS sg13g2f_FILL8
XFILLER_40_1438 VDD VSS sg13g2f_FILL8
XFILLER_40_1446 VDD VSS sg13g2f_FILL8
XFILLER_40_1454 VDD VSS sg13g2f_FILL8
XFILLER_40_1462 VDD VSS sg13g2f_FILL8
XFILLER_40_1470 VDD VSS sg13g2f_FILL8
XFILLER_40_1478 VDD VSS sg13g2f_FILL8
XFILLER_40_1486 VDD VSS sg13g2f_FILL8
XFILLER_40_1494 VDD VSS sg13g2f_FILL4
XFILLER_40_1505 VDD VSS sg13g2f_FILL8
XFILLER_40_1513 VDD VSS sg13g2f_FILL4
XFILLER_40_1517 VDD VSS sg13g2f_FILL1
XFILLER_40_1529 VDD VSS sg13g2f_FILL8
XFILLER_40_1537 VDD VSS sg13g2f_FILL8
XFILLER_40_1545 VDD VSS sg13g2f_FILL4
XFILLER_40_1549 VDD VSS sg13g2f_FILL2
XFILLER_41_1390 VDD VSS sg13g2f_FILL8
XFILLER_41_1398 VDD VSS sg13g2f_FILL8
XFILLER_41_1406 VDD VSS sg13g2f_FILL8
XFILLER_41_1414 VDD VSS sg13g2f_FILL8
XFILLER_41_1422 VDD VSS sg13g2f_FILL8
XFILLER_41_1430 VDD VSS sg13g2f_FILL8
XFILLER_41_1438 VDD VSS sg13g2f_FILL8
XFILLER_41_1446 VDD VSS sg13g2f_FILL8
XFILLER_41_1454 VDD VSS sg13g2f_FILL8
XFILLER_41_1462 VDD VSS sg13g2f_FILL8
XFILLER_41_1470 VDD VSS sg13g2f_FILL8
XFILLER_41_1478 VDD VSS sg13g2f_FILL8
XFILLER_41_1486 VDD VSS sg13g2f_FILL8
XFILLER_41_1494 VDD VSS sg13g2f_FILL8
XFILLER_41_1502 VDD VSS sg13g2f_FILL8
XFILLER_41_1510 VDD VSS sg13g2f_FILL2
XFILLER_41_1512 VDD VSS sg13g2f_FILL1
XFILLER_41_1534 VDD VSS sg13g2f_FILL8
XFILLER_41_1542 VDD VSS sg13g2f_FILL8
XFILLER_41_1550 VDD VSS sg13g2f_FILL1
XFILLER_42_1390 VDD VSS sg13g2f_FILL8
XFILLER_42_1398 VDD VSS sg13g2f_FILL8
XFILLER_42_1406 VDD VSS sg13g2f_FILL8
XFILLER_42_1414 VDD VSS sg13g2f_FILL8
XFILLER_42_1422 VDD VSS sg13g2f_FILL8
XFILLER_42_1430 VDD VSS sg13g2f_FILL8
XFILLER_42_1438 VDD VSS sg13g2f_FILL8
XFILLER_42_1446 VDD VSS sg13g2f_FILL8
XFILLER_42_1454 VDD VSS sg13g2f_FILL8
XFILLER_42_1462 VDD VSS sg13g2f_FILL8
XFILLER_42_1470 VDD VSS sg13g2f_FILL8
XFILLER_42_1478 VDD VSS sg13g2f_FILL8
XFILLER_42_1486 VDD VSS sg13g2f_FILL8
XFILLER_42_1494 VDD VSS sg13g2f_FILL4
XFILLER_42_1505 VDD VSS sg13g2f_FILL8
XFILLER_42_1513 VDD VSS sg13g2f_FILL4
XFILLER_42_1531 VDD VSS sg13g2f_FILL8
XFILLER_42_1539 VDD VSS sg13g2f_FILL8
XFILLER_42_1547 VDD VSS sg13g2f_FILL4
XFILLER_43_1390 VDD VSS sg13g2f_FILL8
XFILLER_43_1398 VDD VSS sg13g2f_FILL8
XFILLER_43_1406 VDD VSS sg13g2f_FILL8
XFILLER_43_1414 VDD VSS sg13g2f_FILL8
XFILLER_43_1422 VDD VSS sg13g2f_FILL8
XFILLER_43_1430 VDD VSS sg13g2f_FILL8
XFILLER_43_1438 VDD VSS sg13g2f_FILL8
XFILLER_43_1446 VDD VSS sg13g2f_FILL8
XFILLER_43_1454 VDD VSS sg13g2f_FILL8
XFILLER_43_1462 VDD VSS sg13g2f_FILL8
XFILLER_43_1470 VDD VSS sg13g2f_FILL8
XFILLER_43_1478 VDD VSS sg13g2f_FILL8
XFILLER_43_1486 VDD VSS sg13g2f_FILL8
XFILLER_43_1494 VDD VSS sg13g2f_FILL8
XFILLER_43_1502 VDD VSS sg13g2f_FILL8
XFILLER_43_1510 VDD VSS sg13g2f_FILL8
XFILLER_43_1529 VDD VSS sg13g2f_FILL8
XFILLER_43_1537 VDD VSS sg13g2f_FILL8
XFILLER_43_1545 VDD VSS sg13g2f_FILL4
XFILLER_43_1549 VDD VSS sg13g2f_FILL2
XFILLER_44_1390 VDD VSS sg13g2f_FILL8
XFILLER_44_1398 VDD VSS sg13g2f_FILL8
XFILLER_44_1406 VDD VSS sg13g2f_FILL8
XFILLER_44_1414 VDD VSS sg13g2f_FILL8
XFILLER_44_1422 VDD VSS sg13g2f_FILL8
XFILLER_44_1430 VDD VSS sg13g2f_FILL8
XFILLER_44_1438 VDD VSS sg13g2f_FILL8
XFILLER_44_1446 VDD VSS sg13g2f_FILL8
XFILLER_44_1454 VDD VSS sg13g2f_FILL8
XFILLER_44_1462 VDD VSS sg13g2f_FILL8
XFILLER_44_1470 VDD VSS sg13g2f_FILL8
XFILLER_44_1478 VDD VSS sg13g2f_FILL8
XFILLER_44_1486 VDD VSS sg13g2f_FILL8
XFILLER_44_1494 VDD VSS sg13g2f_FILL4
XFILLER_44_1547 VDD VSS sg13g2f_FILL4
XFILLER_45_1390 VDD VSS sg13g2f_FILL8
XFILLER_45_1398 VDD VSS sg13g2f_FILL8
XFILLER_45_1406 VDD VSS sg13g2f_FILL8
XFILLER_45_1414 VDD VSS sg13g2f_FILL8
XFILLER_45_1422 VDD VSS sg13g2f_FILL8
XFILLER_45_1430 VDD VSS sg13g2f_FILL8
XFILLER_45_1438 VDD VSS sg13g2f_FILL8
XFILLER_45_1446 VDD VSS sg13g2f_FILL8
XFILLER_45_1454 VDD VSS sg13g2f_FILL8
XFILLER_45_1462 VDD VSS sg13g2f_FILL8
XFILLER_45_1470 VDD VSS sg13g2f_FILL8
XFILLER_45_1478 VDD VSS sg13g2f_FILL8
XFILLER_45_1486 VDD VSS sg13g2f_FILL8
XFILLER_45_1494 VDD VSS sg13g2f_FILL8
XFILLER_45_1502 VDD VSS sg13g2f_FILL8
XFILLER_45_1510 VDD VSS sg13g2f_FILL8
XFILLER_45_1529 VDD VSS sg13g2f_FILL8
XFILLER_45_1537 VDD VSS sg13g2f_FILL8
XFILLER_45_1545 VDD VSS sg13g2f_FILL4
XFILLER_45_1549 VDD VSS sg13g2f_FILL2
XFILLER_46_1390 VDD VSS sg13g2f_FILL8
XFILLER_46_1398 VDD VSS sg13g2f_FILL8
XFILLER_46_1406 VDD VSS sg13g2f_FILL8
XFILLER_46_1414 VDD VSS sg13g2f_FILL8
XFILLER_46_1422 VDD VSS sg13g2f_FILL8
XFILLER_46_1430 VDD VSS sg13g2f_FILL8
XFILLER_46_1438 VDD VSS sg13g2f_FILL8
XFILLER_46_1446 VDD VSS sg13g2f_FILL8
XFILLER_46_1454 VDD VSS sg13g2f_FILL8
XFILLER_46_1462 VDD VSS sg13g2f_FILL8
XFILLER_46_1470 VDD VSS sg13g2f_FILL8
XFILLER_46_1478 VDD VSS sg13g2f_FILL8
XFILLER_46_1486 VDD VSS sg13g2f_FILL8
XFILLER_46_1494 VDD VSS sg13g2f_FILL4
XFILLER_46_1505 VDD VSS sg13g2f_FILL8
XFILLER_46_1513 VDD VSS sg13g2f_FILL4
XFILLER_46_1517 VDD VSS sg13g2f_FILL1
XFILLER_46_1537 VDD VSS sg13g2f_FILL8
XFILLER_46_1545 VDD VSS sg13g2f_FILL4
XFILLER_46_1549 VDD VSS sg13g2f_FILL2
XFILLER_47_1390 VDD VSS sg13g2f_FILL8
XFILLER_47_1398 VDD VSS sg13g2f_FILL8
XFILLER_47_1406 VDD VSS sg13g2f_FILL8
XFILLER_47_1414 VDD VSS sg13g2f_FILL8
XFILLER_47_1422 VDD VSS sg13g2f_FILL8
XFILLER_47_1430 VDD VSS sg13g2f_FILL8
XFILLER_47_1438 VDD VSS sg13g2f_FILL8
XFILLER_47_1446 VDD VSS sg13g2f_FILL8
XFILLER_47_1454 VDD VSS sg13g2f_FILL8
XFILLER_47_1462 VDD VSS sg13g2f_FILL8
XFILLER_47_1470 VDD VSS sg13g2f_FILL8
XFILLER_47_1478 VDD VSS sg13g2f_FILL8
XFILLER_47_1486 VDD VSS sg13g2f_FILL8
XFILLER_47_1494 VDD VSS sg13g2f_FILL8
XFILLER_47_1502 VDD VSS sg13g2f_FILL4
XFILLER_47_1506 VDD VSS sg13g2f_FILL1
XFILLER_47_1534 VDD VSS sg13g2f_FILL8
XFILLER_47_1542 VDD VSS sg13g2f_FILL8
XFILLER_47_1550 VDD VSS sg13g2f_FILL1
XFILLER_48_1390 VDD VSS sg13g2f_FILL8
XFILLER_48_1398 VDD VSS sg13g2f_FILL8
XFILLER_48_1406 VDD VSS sg13g2f_FILL8
XFILLER_48_1414 VDD VSS sg13g2f_FILL8
XFILLER_48_1422 VDD VSS sg13g2f_FILL8
XFILLER_48_1430 VDD VSS sg13g2f_FILL8
XFILLER_48_1438 VDD VSS sg13g2f_FILL8
XFILLER_48_1446 VDD VSS sg13g2f_FILL8
XFILLER_48_1454 VDD VSS sg13g2f_FILL8
XFILLER_48_1462 VDD VSS sg13g2f_FILL8
XFILLER_48_1470 VDD VSS sg13g2f_FILL8
XFILLER_48_1478 VDD VSS sg13g2f_FILL8
XFILLER_48_1486 VDD VSS sg13g2f_FILL8
XFILLER_48_1494 VDD VSS sg13g2f_FILL4
XFILLER_48_1505 VDD VSS sg13g2f_FILL8
XFILLER_48_1513 VDD VSS sg13g2f_FILL4
XFILLER_48_1517 VDD VSS sg13g2f_FILL1
XFILLER_48_1529 VDD VSS sg13g2f_FILL8
XFILLER_48_1537 VDD VSS sg13g2f_FILL8
XFILLER_48_1545 VDD VSS sg13g2f_FILL4
XFILLER_48_1549 VDD VSS sg13g2f_FILL2
XFILLER_49_1390 VDD VSS sg13g2f_FILL8
XFILLER_49_1398 VDD VSS sg13g2f_FILL8
XFILLER_49_1406 VDD VSS sg13g2f_FILL8
XFILLER_49_1414 VDD VSS sg13g2f_FILL8
XFILLER_49_1422 VDD VSS sg13g2f_FILL8
XFILLER_49_1430 VDD VSS sg13g2f_FILL8
XFILLER_49_1438 VDD VSS sg13g2f_FILL8
XFILLER_49_1446 VDD VSS sg13g2f_FILL8
XFILLER_49_1454 VDD VSS sg13g2f_FILL8
XFILLER_49_1462 VDD VSS sg13g2f_FILL8
XFILLER_49_1470 VDD VSS sg13g2f_FILL8
XFILLER_49_1478 VDD VSS sg13g2f_FILL8
XFILLER_49_1486 VDD VSS sg13g2f_FILL8
XFILLER_49_1494 VDD VSS sg13g2f_FILL8
XFILLER_49_1502 VDD VSS sg13g2f_FILL8
XFILLER_49_1510 VDD VSS sg13g2f_FILL8
XFILLER_49_1518 VDD VSS sg13g2f_FILL8
XFILLER_49_1526 VDD VSS sg13g2f_FILL8
XFILLER_49_1534 VDD VSS sg13g2f_FILL8
XFILLER_49_1542 VDD VSS sg13g2f_FILL8
XFILLER_49_1550 VDD VSS sg13g2f_FILL1
XFILLER_50_1390 VDD VSS sg13g2f_FILL8
XFILLER_50_1398 VDD VSS sg13g2f_FILL8
XFILLER_50_1406 VDD VSS sg13g2f_FILL8
XFILLER_50_1414 VDD VSS sg13g2f_FILL8
XFILLER_50_1422 VDD VSS sg13g2f_FILL8
XFILLER_50_1430 VDD VSS sg13g2f_FILL8
XFILLER_50_1438 VDD VSS sg13g2f_FILL8
XFILLER_50_1446 VDD VSS sg13g2f_FILL8
XFILLER_50_1454 VDD VSS sg13g2f_FILL8
XFILLER_50_1462 VDD VSS sg13g2f_FILL8
XFILLER_50_1470 VDD VSS sg13g2f_FILL8
XFILLER_50_1478 VDD VSS sg13g2f_FILL8
XFILLER_50_1486 VDD VSS sg13g2f_FILL8
XFILLER_50_1494 VDD VSS sg13g2f_FILL4
XFILLER_50_1505 VDD VSS sg13g2f_FILL8
XFILLER_50_1513 VDD VSS sg13g2f_FILL8
XFILLER_50_1521 VDD VSS sg13g2f_FILL8
XFILLER_50_1529 VDD VSS sg13g2f_FILL8
XFILLER_50_1537 VDD VSS sg13g2f_FILL8
XFILLER_50_1545 VDD VSS sg13g2f_FILL4
XFILLER_50_1549 VDD VSS sg13g2f_FILL2
XFILLER_51_1390 VDD VSS sg13g2f_FILL8
XFILLER_51_1398 VDD VSS sg13g2f_FILL8
XFILLER_51_1406 VDD VSS sg13g2f_FILL8
XFILLER_51_1414 VDD VSS sg13g2f_FILL8
XFILLER_51_1422 VDD VSS sg13g2f_FILL8
XFILLER_51_1430 VDD VSS sg13g2f_FILL8
XFILLER_51_1438 VDD VSS sg13g2f_FILL8
XFILLER_51_1446 VDD VSS sg13g2f_FILL8
XFILLER_51_1454 VDD VSS sg13g2f_FILL8
XFILLER_51_1462 VDD VSS sg13g2f_FILL8
XFILLER_51_1470 VDD VSS sg13g2f_FILL8
XFILLER_51_1478 VDD VSS sg13g2f_FILL8
XFILLER_51_1486 VDD VSS sg13g2f_FILL8
XFILLER_51_1494 VDD VSS sg13g2f_FILL8
XFILLER_51_1502 VDD VSS sg13g2f_FILL8
XFILLER_51_1533 VDD VSS sg13g2f_FILL8
XFILLER_51_1541 VDD VSS sg13g2f_FILL8
XFILLER_51_1549 VDD VSS sg13g2f_FILL2
XFILLER_52_1390 VDD VSS sg13g2f_FILL8
XFILLER_52_1398 VDD VSS sg13g2f_FILL8
XFILLER_52_1406 VDD VSS sg13g2f_FILL8
XFILLER_52_1414 VDD VSS sg13g2f_FILL8
XFILLER_52_1422 VDD VSS sg13g2f_FILL8
XFILLER_52_1430 VDD VSS sg13g2f_FILL8
XFILLER_52_1438 VDD VSS sg13g2f_FILL8
XFILLER_52_1446 VDD VSS sg13g2f_FILL8
XFILLER_52_1454 VDD VSS sg13g2f_FILL8
XFILLER_52_1462 VDD VSS sg13g2f_FILL8
XFILLER_52_1470 VDD VSS sg13g2f_FILL8
XFILLER_52_1478 VDD VSS sg13g2f_FILL8
XFILLER_52_1486 VDD VSS sg13g2f_FILL8
XFILLER_52_1494 VDD VSS sg13g2f_FILL1
XFILLER_52_1502 VDD VSS sg13g2f_FILL8
XFILLER_52_1510 VDD VSS sg13g2f_FILL8
XFILLER_52_1518 VDD VSS sg13g2f_FILL8
XFILLER_52_1526 VDD VSS sg13g2f_FILL8
XFILLER_52_1534 VDD VSS sg13g2f_FILL8
XFILLER_52_1542 VDD VSS sg13g2f_FILL8
XFILLER_52_1550 VDD VSS sg13g2f_FILL1
.ENDS SARADC
