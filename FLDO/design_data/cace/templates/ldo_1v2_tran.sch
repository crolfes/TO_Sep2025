** sch_path: FLDO/design_data/cace/templates/ldo_1v2_tran.sch
**.subckt ldo_1v2_tran
x1 VCC GND ref Ibias_1u_1 net1 enable_n ldo_1v2
Vcc VCC GND PWL(0 0 1u CACE{vcc})
V1 ref GND 1.0
Cload out GND 1n m=1
Rload out GND 12k m=1
Vmeas2 net1 out 0
.save i(vmeas2)
I0 VCC Ibias_1u_1 1u
V2 enable_n GND PWL(0 CACE{vcc} 1u CACE{vcc} 1.1u 0)
**** begin user architecture code


** IHP models
.lib cornerMOSlv.lib mos_CACE{mos_corner}
.lib cornerMOShv.lib mos_CACE{mos_corner}
.lib cornerRES.lib res_CACE{passives_corner}
.lib cornerCAP.lib cap_CACE{passives_corner}





.include CACE{DUT_path}
.temp CACE{temp}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.save all
.control
  tran 100n 200u

  meas tran v_out AVG v(out) FROM=190u TO=200u
  meas tran v_max MAX v(out)
  meas tran i_source AVG i(vcc) FROM=190u TO=200u

  let i_out = v_out / 12k

  let i_supply =  - i_source - i_out

  echo $&v_out $&v_max $&i_supply > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



**** end user architecture code
**.ends

* expanding   symbol:  ldo_1v2.sym # of pins=6
** sym_path: FLDO/design_data/xschem/ldo_1v2.sym
** sch_path: FLDO/design_data/xschem/ldo_1v2.sch
.subckt ldo_1v2 VCC GND ref Ibias_1u out en_n
*.iopin VCC
*.iopin GND
*.ipin ref
*.ipin Ibias_1u
*.opin out
*.ipin en_n
XM4 out vg net1 net1 sg13_hv_pmos w=50u l=0.4u ng=10 m=1 mm_ok=1
Vmeas VCC net1 0
.save i(vmeas)
XC1 out vg cap_cmim w=10.0e-6 l=10.0e-6 m=1
XM2 Ibias_1u en_n GND GND sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM3 vg en VCC VCC sg13_hv_pmos w=0.3u l=0.4u ng=1 m=1 mm_ok=1
XM1 en en_n GND GND sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM11 en en_n VCC VCC sg13_hv_pmos w=0.3u l=0.4u ng=1 m=1 mm_ok=1
XRdummy GND GND gnd rhigh w=0.5e-6 l=4e-6 m=2 b=0 mm_ok=1
x1 VCC GND Ibias_1u fb ref vg ldo_ota
XR2 fb out gnd rhigh w=0.5e-6 l=4*4e-6 m=1 b=0
XR1 GND fb gnd rhigh w=0.5e-6 l=20*4e-6 m=1 b=0
.ends


* expanding   symbol:  ldo_ota.sym # of pins=6
** sym_path: FLDO/design_data/xschem/ldo_ota.sym
** sch_path: FLDO/design_data/xschem/ldo_ota.sch
.subckt ldo_ota VCC GND Ibias_1u plus min out
*.iopin VCC
*.iopin GND
*.ipin plus
*.ipin min
*.opin out
*.ipin Ibias_1u
XM5 vbp plus tail GND sg13_hv_nmos w=3u l=2u ng=3 m=1 mm_ok=1
XM6 out min tail GND sg13_hv_nmos w=3u l=2u ng=3 m=1 mm_ok=1
XM7 tail Ibias_1u GND GND sg13_hv_nmos w=1u l=2u ng=1 m=2 mm_ok=1
XM8 Ibias_1u Ibias_1u GND GND sg13_hv_nmos w=1u l=2u ng=1 m=1 mm_ok=1
XM9 out vbp VCC VCC sg13_hv_pmos w=2u l=2u ng=2 m=1 mm_ok=1
XM10 vbp vbp VCC VCC sg13_hv_pmos w=2u l=2u ng=2 m=1 mm_ok=1
XMdummy0 GND Ibias_1u GND GND sg13_hv_nmos w=1u l=2u ng=1 m=2 mm_ok=1
XMdummy1 tail tail tail GND sg13_hv_nmos w=1u l=2u ng=1 m=4 mm_ok=1
XMdummyP VCC vbp VCC VCC sg13_hv_pmos w=1u l=2u ng=1 m=2 mm_ok=1
.ends

.end
