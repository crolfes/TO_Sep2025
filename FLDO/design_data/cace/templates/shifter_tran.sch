** sch_path: FLDO/design_data/cace/templates/shifter_tran.sch
**.subckt shifter_tran
Vdd VDD 0 CACE{vdd_1v2}
Vcc VCC 0 CACE{vdd_3v3}
Vin in 0 pulse(0 CACE{vdd_1v2} 10n 0.05n 0.05n 20n 40n)
x1 VCC VDD 0 in out shifter
C1 out 0 CACE{cload} m=1
**** begin user architecture code

.option gmin=1e-15 method=gear trtol=1
.include CACE{DUT_path}
.temp CACE{temp}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.save all

.control
  tran 1n 40n

  let vin_mid=CACE{vdd_1v2}*0.5
  let vout_mid=CACE{vdd_3v3}*0.5
  let vout_low=CACE{vdd_3v3}*0.1
  let vout_high=CACE{vdd_3v3}*0.9

  meas tran t_rise TRIG v(out) VAL=vout_low  RISE=1 TARG v(out) VAL=vout_high RISE=1
  meas tran t_fall TRIG v(out) VAL=vout_high FALL=1 TARG v(out) VAL=vout_low  FALL=1

  meas tran t_prop TRIG v(in) VAL=vin_mid RISE=1 TARG v(out) VAL=vout_mid RISE=1

  echo $&t_rise $&t_fall $&t_prop > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc




.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}


**** end user architecture code
**.ends

* expanding   symbol:  shifter.sym # of pins=5
** sym_path: FLDO/design_data/xschem/shifter.sym
** sch_path: FLDO/design_data/xschem/shifter.sch
.subckt shifter VDD_3v3 VDD_1v2 GND in out
*.iopin VDD_3v3
*.iopin VDD_1v2
*.iopin GND
*.ipin in
*.opin out
XM1 lvlsh in_b GND GND sg13_hv_nmos w=2u l=0.45u ng=1 m=1 mm_ok=1
XM2 lvlsh_b in GND GND sg13_hv_nmos w=2u l=0.45u ng=1 m=1 mm_ok=1
XM3 lvlsh lvlsh_b VDD_3v3 VDD_3v3 sg13_hv_pmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM4 lvlsh_b lvlsh VDD_3v3 VDD_3v3 sg13_hv_pmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM5 in_b in GND GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM6 in_b in VDD_1v2 VDD_1v2 sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
XM7 out lvlsh_b GND GND sg13_hv_nmos w=2u l=0.45u ng=1 m=1 mm_ok=1
XM8 out lvlsh_b VDD_3v3 VDD_3v3 sg13_hv_pmos w=2u l=0.4u ng=1 m=2 mm_ok=1
.ends

.end
