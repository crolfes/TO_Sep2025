** sch_path: FLDO/design_data/cace/templates/biasgen_tran.sch
**.subckt biasgen_tran
VCC VCC GND PWL(0 0 1u CACE{vcc})
x1 VCC GND Ibias_1u_1 Ibias_1u_2 Ibias_1u_3 por biasgen
R1 Ibias_1u_1 GND 100k m=1
R2 Ibias_1u_2 GND 1MEG m=1
R3 Ibias_1u_3 GND 10k m=1
C1 por GND 10f m=1
**** begin user architecture code


** IHP models
.lib cornerMOSlv.lib mos_CACE{mos_corner}
.lib cornerMOShv.lib mos_CACE{mos_corner}
.lib cornerRES.lib res_CACE{passives_corner}
.lib cornerCAP.lib cap_CACE{passives_corner}





.include CACE{DUT_path}
.temp CACE{temp}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.save all
.control
  tran 10n 3u

  meas tran t_startup WHEN v(por)=1 FALL=1
  meas tran v_out_1 AVG Ibias_1u_1 FROM=2u TO=3u
  meas tran v_out_2 AVG Ibias_1u_2 FROM=2u TO=3u
  meas tran v_out_3 AVG Ibias_1u_3 FROM=2u TO=3u
  meas tran i_source AVG i(vcc) FROM=2u TO=3u

  let i_out_1 = v_out_1 / 100k
  let i_out_2 = v_out_2 / 1MEG
  let i_out_3 = v_out_3 / 10k

  let i_supply =  - i_source - i_out_1 - i_out_2 - i_out_3

  echo $&i_out_1 $&i_out_2 $&i_out_3 $&i_supply $&t_startup > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



**** end user architecture code
**.ends

* expanding   symbol:  biasgen.sym # of pins=4
** sym_path: FLDO/design_data/xschem/biasgen.sym
** sch_path: FLDO/design_data/xschem/biasgen.sch
.subckt biasgen VCC GND Ibias_1u_1 Ibias_1u_2 Ibias_1u_3 por
*.iopin VCC
*.iopin GND
*.iopin Ibias_1u_1,Ibias_1u_2,Ibias_1u_3
*.opin por
XM1 vp vn net1 GND sg13_hv_nmos w=2u l=2u ng=1 m=3 mm_ok=1
XM2 vn vn GND GND sg13_hv_nmos w=2u l=2u ng=1 m=1 mm_ok=1
XM3 vn vp VCC VCC sg13_hv_pmos w=0.5u l=2u ng=1 m=2 mm_ok=1
XM4 vp vp VCC VCC sg13_hv_pmos w=0.5u l=2u ng=1 m=2 mm_ok=1
XMout0 Ibias_1u_0 vp VCC VCC sg13_hv_pmos w=0.5u l=2u ng=1 m=1 mm_ok=1
XMout1 Ibias_1u_1 vp VCC VCC sg13_hv_pmos w=0.5u l=2u ng=1 m=1 mm_ok=1
XMout2 Ibias_1u_2 vp VCC VCC sg13_hv_pmos w=0.5u l=2u ng=1 m=1 mm_ok=1
XMout3 Ibias_1u_3 vp VCC VCC sg13_hv_pmos w=0.5u l=2u ng=1 m=1 mm_ok=1
XC1 Ibias_1u_0 GND cap_cmim w=7.0e-6 l=7.0e-6 m=1
XM7 por Ibias_1u_0 VCC VCC sg13_hv_pmos w=0.3u l=0.4u ng=1 m=1 mm_ok=1
XM8 por Ibias_1u_0 GND GND sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XR1 net1 GND GND rppd w=0.5e-6 l=80e-6 m=1 b=0 mm_ok=1
XM5 vp vstart GND GND sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM6 vstart vn GND GND sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM9 vstart vn net2 VCC sg13_hv_pmos w=0.3u l=2u ng=1 m=1 mm_ok=1
XM10 net2 net2 net3 VCC sg13_hv_pmos w=0.3u l=2u ng=1 m=1 mm_ok=1
XM11 net3 net3 VCC VCC sg13_hv_pmos w=0.3u l=2u ng=1 m=1 mm_ok=1
.ends

.end
