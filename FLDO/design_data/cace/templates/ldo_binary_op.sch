** sch_path: FLDO/design_data/cace/templates/ldo_binary_op.sch
**.subckt ldo_binary_op
V2 a2 0 DC CACE[CACE{a[2]}*CACE{vcc}]
V3 a1 0 DC CACE[CACE{a[1]}*CACE{vcc}]
V4 a0 0 DC CACE[CACE{a[0]}*CACE{vcc}]
Vcc VCC 0 DC CACE{vcc}
Cload out 0 500f m=1
Rload out 0 12k m=1
V7 a3 0 DC CACE[CACE{a[3]}*CACE{vcc}]
x1 VCC 0 ref Ibias_1u_1 net1 a3 a2 a1 a0 enable_n ldo_binary
V1 ref 0 1.0
Vload net1 out 0
.save i(vload)
I0 VCC Ibias_1u_1 1u
V6 enable_n 0 DC CACE{en_n}
**** begin user architecture code


** IHP models
.lib cornerMOSlv.lib mos_CACE{mos_corner}
.lib cornerMOShv.lib mos_CACE{mos_corner}
.lib cornerRES.lib res_CACE{passives_corner}
.lib cornerCAP.lib cap_CACE{passives_corner}





.include CACE{DUT_path}
.temp CACE{temp}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.save all
.control
  op

  let i_q = - i(vcc) - i(vload)
  echo $&out $&i_q > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



**** end user architecture code
**.ends

* expanding   symbol:  ldo_binary.sym # of pins=7
** sym_path: FLDO/design_data/xschem/ldo_binary.sym
** sch_path: FLDO/design_data/xschem/ldo_binary.sch
.subckt ldo_binary VCC GND ref Ibias_1u out a3 a2 a1 a0 en_n
*.iopin VCC
*.iopin GND
*.ipin ref
*.ipin Ibias_1u
*.opin out
*.ipin a3,a2,a1,a0
*.ipin en_n
XR4 net1 out GND rhigh w=0.5e-6 l=12e-6 m=1 b=0
XM1 net1 a0 out VCC sg13_hv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM2 net2 a1 net1 VCC sg13_hv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM3 net3 a2 net2 VCC sg13_hv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM4 out vg net4 net4 sg13_hv_pmos w=100u l=0.4u ng=10 m=1 mm_ok=1
Vmeas VCC net4 0
.save i(vmeas)
XC1 out vg cap_cmim w=10.0e-6 l=10.0e-6 m=1
XM11 net5 a3 net3 VCC sg13_hv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM15 vg en VCC VCC sg13_hv_pmos w=0.3u l=0.4u ng=1 m=1 mm_ok=1
x1 VCC GND Ibias_1u fb ref vg ldo_ota
XM5 Ibias_1u en_n GND GND sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM6 en en_n GND GND sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM7 en en_n VCC VCC sg13_hv_pmos w=0.3u l=0.4u ng=1 m=1 mm_ok=1
XRdummy GND GND gnd rhigh w=0.5e-6 l=12e-6 m=5 b=0
XR2 net2 net1 GND rhigh w=0.5e-6 l=2*12e-6 m=1 b=0
XR6 net3 net2 GND rhigh w=0.5e-6 l=4*12e-6 m=1 b=0
XR5 net5 net3 GND rhigh w=0.5e-6 l=8*12e-6 m=1 b=0
XR3 fb net5 GND rhigh w=0.5e-6 l=6*12e-6 m=1 b=0
XR1 GND fb GND rhigh w=0.5e-6 l=10*12e-6 m=1 b=0
.ends


* expanding   symbol:  ldo_ota.sym # of pins=6
** sym_path: FLDO/design_data/xschem/ldo_ota.sym
** sch_path: FLDO/design_data/xschem/ldo_ota.sch
.subckt ldo_ota VCC GND Ibias_1u plus min out
*.iopin VCC
*.iopin GND
*.ipin plus
*.ipin min
*.opin out
*.ipin Ibias_1u
XM5 vbp plus tail GND sg13_hv_nmos w=3u l=2u ng=3 m=1 mm_ok=1
XM6 out min tail GND sg13_hv_nmos w=3u l=2u ng=3 m=1 mm_ok=1
XM7 tail Ibias_1u GND GND sg13_hv_nmos w=1u l=2u ng=1 m=2 mm_ok=1
XM8 Ibias_1u Ibias_1u GND GND sg13_hv_nmos w=1u l=2u ng=1 m=1 mm_ok=1
XM9 out vbp VCC VCC sg13_hv_pmos w=2u l=2u ng=2 m=1 mm_ok=1
XM10 vbp vbp VCC VCC sg13_hv_pmos w=2u l=2u ng=2 m=1 mm_ok=1
XMdummy0 GND Ibias_1u GND GND sg13_hv_nmos w=1u l=2u ng=1 m=2 mm_ok=1
XMdummy1 tail tail tail GND sg13_hv_nmos w=1u l=2u ng=1 m=4 mm_ok=1
XMdummyP VCC vbp VCC VCC sg13_hv_pmos w=1u l=2u ng=1 m=2 mm_ok=1
.ends

.end
