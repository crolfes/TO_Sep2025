** sch_path: FLDO/design_data/xschem/resistors-binary.sch
**.subckt resistors-binary
XR1 0 fb reshigh_chain.tcl_@n W=0.5e-6 L=5e-6 mult=1
V1 ref 0 1
XR4 out net1 sub! rhigh w=0.5e-6 l=5e-6 m=1 b=0 mm_ok=1
XM1 net1 a0 out VCC sg13_hv_pmos w=5u l=0.4u ng=1 m=1 mm_ok=1
XM2 net2 a1 net1 VCC sg13_hv_pmos w=5u l=0.4u ng=1 m=1 mm_ok=1
XM3 net3 a2 net2 VCC sg13_hv_pmos w=5u l=0.4u ng=1 m=1 mm_ok=1
V2 a2_l 0 1.2 pulse(1.2 0 0n 1n 1n 2u 4u)
V3 a1_l 0 1.2 pulse(1.2 0 0n 1n 1n 1u 2u)
V4 a0_l 0 1.2 pulse(1.2 0 0n 1n 1n 500n 1u)
x_shift2 VCC VDD 0 a2_l net5[2] shifter
x_shift1 VCC VDD 0 a1_l net5[1] shifter
x_shift0 VCC VDD 0 a0_l net5[0] shifter
V5 VCC 0 3.3
V6 VDD 0 1.2
XR3 fb net3 reshigh_chain.tcl_@n W=0.5e-6 L=5e-6 mult=1
B1 vg 0 V = 'max(0, min(3.3, -V(ref,fb)*1e2))'
C1 fb 0 100p m=1
XR10 net3 net2 reshigh_chain.tcl_@n W=0.5e-6 L=5e-6 mult=1
XR2 net2 net1 reshigh_chain.tcl_@n W=0.5e-6 L=5e-6 mult=1
XM4 out vg net4 net4 sg13_hv_pmos w=40u l=0.4u ng=4 m=1 mm_ok=1
C2 out 0 200f m=1
Vmeas VCC net4 0
.save i(vmeas)
XRload 0 out reshigh_chain.tcl_@n W=0.5e-6 L=5e-6 mult=1
**** begin user architecture code


** IHP models
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ



*.option method=gear trtol=1
.save all
.tran 10n 5u
.control
  run
  write resistors-binary.raw
  quit
.endc


**** end user architecture code
**.ends
.end
