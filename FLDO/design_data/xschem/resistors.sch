** sch_path: FLDO/design_data/xschem/resistors.sch
**.subckt resistors
XR1 0 fb reshigh_chain.tcl_@n W=0.5e-6 L=10e-6 mult=1
V1 ref 0 1
XR2 net3 net7 sub! rhigh w=0.5e-6 l=10e-6 m=1 b=0 mm_ok=1
XR3 net1 net3 sub! rhigh w=0.5e-6 l=10e-6 m=1 b=0 mm_ok=1
XR4 net2 net1 sub! rhigh w=0.5e-6 l=10e-6 m=1 b=0 mm_ok=1
XM1 net1 a2 net2 VCC sg13_hv_pmos w=10u l=0.4u ng=1 m=1 mm_ok=1
XM2 net3 a1 net1 VCC sg13_hv_pmos w=10u l=0.4u ng=1 m=1 mm_ok=1
XM3 net7 a2 net3 VCC sg13_hv_pmos w=10u l=0.4u ng=1 m=1 mm_ok=1
V2 a2_l 0 1.2 pulse(1.2 0 0n 1n 1n 2u 4u)
V3 a1_l 0 1.2 pulse(1.2 0 0n 1n 1n 1u 2u)
V4 a0_l 0 1.2 pulse(1.2 0 0n 1n 1n 500n 1u)
x_shift2 VCC VDD 0 a2_l net8[2] shifter
x_shift1 VCC VDD 0 a1_l net8[1] shifter
x_shift0 VCC VDD 0 a0_l net8[0] shifter
V5 VCC 0 3.3
V6 VDD 0 1.2
XR5 net6 net2 sub! rhigh w=0.5e-6 l=10e-6 m=1 b=0 mm_ok=1
XR6 net4 net6 sub! rhigh w=0.5e-6 l=10e-6 m=1 b=0 mm_ok=1
XR7 net5 net4 sub! rhigh w=0.5e-6 l=10e-6 m=1 b=0 mm_ok=1
XM4 net4 a1 net5 VCC sg13_hv_pmos w=10u l=0.4u ng=1 m=1 mm_ok=1
XM5 net6 a2 net4 VCC sg13_hv_pmos w=10u l=0.4u ng=1 m=1 mm_ok=1
XM6 net2 a0 net6 VCC sg13_hv_pmos w=10u l=0.4u ng=1 m=1 mm_ok=1
XR8 out net5 sub! rhigh w=0.5e-6 l=10e-6 m=1 b=0 mm_ok=1
XM7 net5 a2 out VCC sg13_hv_pmos w=10u l=0.4u ng=1 m=1 mm_ok=1
XR9 fb net7 reshigh_chain.tcl_@n W=0.5e-6 L=10e-6 mult=1
B1 out 0 V = 'max(0, min(3.3, V(ref,fb)*1e3))'
C1 fb 0 10p m=1
**** begin user architecture code


** IHP models
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ



.option method=gear trtol=1
.save all
.tran 10n 4u
.control
  run
  write resistors.raw
  quit
.endc


**** end user architecture code
**.ends
.end
